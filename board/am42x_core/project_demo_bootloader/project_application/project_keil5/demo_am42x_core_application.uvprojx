# Keil uVision project demo_am42x_core_application.uvprojx, settings and files
target debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32L196PCTA HDSC
  pack: HDSC.HC32L19X.1.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: demo_am42x_core_application +hex
  AfterMake: fromelf --bincombined -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG,AM_CORTEX_M0
  c include: ..\..\..\..\..\3rdparty/CMSIS/Include;..\..\..\..\..\arch/arm/include;..\..\..\..\..\components/drivers/include;..\..\..\..\..\components/libc/armlib_adapter/include;..\..\..\..\..\components/libc/microlib_adapter/include;..\..\..\..\..\components/service/include;..\..\..\..\..\components/util/include;..\user_code;..\user_config;..\user_config/am_hwconf_usrcfg;..\user_config/am_servconf_usrcfg;..\..\..\..\..\board/bsp_common/include;..\..\..\..\..\examples/components;..\..\..\..\..\examples/soc/zlg;..\..\..\..\..\examples/std;..\..\..\..\..\examples\board\am42x_core;..\..\..\..\..\interface;..\..\..\..\..\soc\zlg\zsl42x;..\..\..\..\..\soc\zlg\drivers\include\adc;..\..\..\..\..\soc\zlg\drivers\include\adtim;..\..\..\..\..\soc\zlg\drivers\include\aes;..\..\..\..\..\soc\zlg\drivers\include\clk;..\..\..\..\..\soc\zlg\drivers\include\clktrim;..\..\..\..\..\soc\zlg\drivers\include\crc;..\..\..\..\..\soc\zlg\drivers\include\dac;..\..\..\..\..\soc\zlg\drivers\include\dma;..\..\..\..\..\soc\zlg\drivers\include\flash;..\..\..\..\..\soc\zlg\drivers\include\gpio;..\..\..\..\..\soc\zlg\drivers\include\i2c;..\..\..\..\..\soc\zlg\drivers\include\lcd;..\..\..\..\..\soc\zlg\drivers\include\lpmode;..\..\..\..\..\soc\zlg\drivers\include\lptim;..\..\..\..\..\soc\zlg\drivers\include\lpuart;..\..\..\..\..\soc\zlg\drivers\include\lvd;..\..\..\..\..\soc\zlg\drivers\include\opa;..\..\..\..\..\soc\zlg\drivers\include\pca;..\..\..\..\..\soc\zlg\drivers\include\pcnt;..\..\..\..\..\soc\zlg\drivers\include\ram;..\..\..\..\..\soc\zlg\drivers\include\rcc;..\..\..\..\..\soc\zlg\drivers\include\rtc;..\..\..\..\..\soc\zlg\drivers\include\spi;..\..\..\..\..\soc\zlg\drivers\include\tim;..\..\..\..\..\soc\zlg\drivers\include\trng;..\..\..\..\..\soc\zlg\drivers\include\uart;..\..\..\..\..\soc\zlg\drivers\include\vc;..\..\..\..\..\soc\zlg\drivers\include\wdt;..\..\..\..\..\soc\zlg\drivers\include\bootloader;..\user_config\am_bootconf_usrcfg;..\..\..\..\..\examples\components\bootloader;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\bootloader\include\arch\arm;..\..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool;..\..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool\drivers;..\..\..\..\..\components\bootloader\include\core;..\..\..\..\..\components\bootloader\include\drivers;..\..\..\..\..\soc\zlg\drivers\include\lora;..\..\..\..\..\soc\zlg\drivers\include\lpsoftimer
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\demo_am42x_core_application.sct
  group bsp_common
    ../../../../bsp_common/source/: am_bsp_armlib.c am_bsp_microlib.c am_bsp_delay_timer.c am_bsp_system_heap.c am_bsp_isr_defer_pendsv.c
  group arm
    ../../../../../arch/arm/source/: am_arm_nvic.c am_arm_nvic_armcc.s am_arm_systick.c
  group drivers
    ../../../../../components/drivers/source/digitron_key/: am_zlg72128_std.c zlg72128.c zlg72128_platform.c
    ../../../../../components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../../../../../components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../../../../../components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../../../../../components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../../../../../components/drivers/source/fm175xx/: am_fm175xx_ant.c am_fm175xx_zsl42x.lib
    ../../../../../components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../../../../../components/drivers/source/led/: am_led_gpio.c am_led_hc595.c
    ../../../../../components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../../../../../components/drivers/source/temperature/: am_temp_lm75.c
    ../../../../../components/drivers/source/miniport/: am_miniport_view_key.c am_miniport_view_key_595.c
    ../../../../../components/drivers/source/sensor/: am_sensor_hts221.c
    ../../../../../components/drivers/source/rtc/: am_rx8025t.c am_ds1302.c am_pcf85063.c am_rx8025sa.c
    ../../../../../components/drivers/source/ble/: am_zlg9021.c am_zlg52810.c
    ../../../../../components/drivers/source/flash/: am_is25xx.c am_mx25xx.c
    ../../../../../components/drivers/source/fram/: am_fm25clxx.c am_mb85rsxx.c
    ../../../../../components/drivers/source/gs200/: am_gs200.c
    ../../../../../components/drivers/source/mk100/: am_mk100.c
    ../../../../../components/drivers/source/nvram/: am_ep24cxx.c
    ../../../../../components/drivers/source/rs200/: am_rs200.c
    ../../../../../components/drivers/source/zigbee/: am_zm516x.c
    ../../../../../components/drivers/source/zlg600/: am_zlg600.c
    ../../../../../components/drivers/source/zsn603/: zsn603.c zsn603_platform.c
  group libc
    ../../../../../components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../../../../../components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../../../../../components/service/source/: am_adc.c am_buzzer_dev.c am_event_category_input.c am_dac.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_timer.c am_uart.c am_uart_rngbuf.c am_crc_soft.c am_crc_table_def.c am_sdio.c am_sensor.c am_xmodem.c am_baudrate_detect.c
  group util
    ../../../../../components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c
  group soc
    ../../../../../soc/zlg/drivers/source/adc/: am_zsl42x_adc.c
    ../../../../../soc/zlg/drivers/source/adtim/hw/: amhw_zsl42x_adtim.c
    ../../../../../soc/zlg/drivers/source/adtim/: am_zsl42x_adtim_cap.c am_zsl42x_adtim_pwm.c am_zsl42x_adtim_timing.c
    ../../../../../soc/zlg/drivers/source/aes/: am_zsl42x_aes.c
    ../../../../../soc/zlg/drivers/source/bootloader/: am_zsl42x_boot_flash.c
    ../../../../../soc/zlg/drivers/source/clk/: am_zsl42x_clk.c
    ../../../../../soc/zlg/drivers/source/clktrim/: am_zsl42x_clktrim.c
    ../../../../../soc/zlg/drivers/source/crc/: am_zsl42x_crc.c
    ../../../../../soc/zlg/drivers/source/dac/: am_zsl42x_dac.c
    ../../../../../soc/zlg/drivers/source/dma/: am_zsl42x_dma.c
    ../../../../../soc/zlg/drivers/source/flash/: am_zsl42x_flash.c
    ../../../../../soc/zlg/drivers/source/gpio/hw/: amhw_zsl42x_gpio.c
    ../../../../../soc/zlg/drivers/source/gpio/: am_zsl42x_gpio.c
    ../../../../../soc/zlg/drivers/source/i2c/: am_zsl42x_i2c.c am_zsl42x_i2c_slv.c
    ../../../../../soc/zlg/drivers/source/lcd/: am_zsl42x_lcd.c
    ../../../../../soc/zlg/drivers/source/lptim/: am_zsl42x_lptim_timing.c
    ../../../../../soc/zlg/drivers/source/lpuart/hw/: amhw_zsl42x_lpuart.c
    ../../../../../soc/zlg/drivers/source/lpuart/: am_zsl42x_lpuart.c
    ../../../../../soc/zlg/drivers/source/lvd/: am_zsl42x_lvd.c
    ../../../../../soc/zlg/drivers/source/opa/: am_zsl42x_opa.c
    ../../../../../soc/zlg/drivers/source/pca/: am_zsl42x_pca.c
    ../../../../../soc/zlg/drivers/source/pcnt/: am_zsl42x_pcnt.c
    ../../../../../soc/zlg/drivers/source/ram/: am_zsl42x_ram.c
    ../../../../../soc/zlg/drivers/source/rcc/hw/: amhw_zsl42x_rcc.c amhw_zsl42x_rcc_reset.c
    ../../../../../soc/zlg/drivers/source/rtc/: am_zsl42x_rtc.c
    ../../../../../soc/zlg/drivers/source/spi/: am_zsl42x_spi_dma.c am_zsl42x_spi_int.c am_zsl42x_spi_poll.c
    ../../../../../soc/zlg/drivers/source/tim/: am_zsl42x_tim_cap.c am_zsl42x_tim_pwm.c am_zsl42x_tim_timing.c
    ../../../../../soc/zlg/drivers/source/trng/: am_zsl42x_trng.c
    ../../../../../soc/zlg/drivers/source/uart/hw/: amhw_zsl42x_uart.c
    ../../../../../soc/zlg/drivers/source/uart/: am_zsl42x_uart.c
    ../../../../../soc/zlg/drivers/source/vc/: am_zsl42x_vc.c
    ../../../../../soc/zlg/drivers/source/wdt/: am_zsl42x_wdt.c
    ../../../../../soc/zlg/drivers/source/lpsoftimer/: am_zsl42x_lpsoftimer.c am_zsl42x_lpsoftimer_if.c
    ../../../../../soc/zlg/drivers/source/lora/: am_zsl42x_lora.c am_zsl42x_lora_if_spi.c am_zsl42x_lora_reg.c
  group examples_board
    ../../../../../examples/board/am42x_core/adc/: demo_zsl42x_core_hw_adc_dma.c demo_zsl42x_core_hw_adc_int.c demo_zsl42x_core_hw_multichan_adc.c demo_zsl42x_core_std_adc.c demo_zsl42x_core_std_multichan_adc.c
    ../../../../../examples/board/am42x_core/aes/: demo_zsl42x_core_aes_ency_decy.c
    ../../../../../examples/board/am42x_core/buzzer/: demo_zsl42x_core_std_buzzer.c
    ../../../../../examples/board/am42x_core/clk/: demo_zsl42x_core_hw_clk.c
    ../../../../../examples/board/am42x_core/crc/: demo_zsl42x_core_std_crc.c
    ../../../../../examples/board/am42x_core/dac/: demo_zsl42x_core_hw_dac_dma.c demo_zsl42x_core_std_dac.c
    ../../../../../examples/board/am42x_core/delay/: demo_zsl42x_core_std_delay.c
    ../../../../../examples/board/am42x_core/dma/: demo_zsl42x_core_drv_dma_m2m.c
    ../../../../../examples/board/am42x_core/flash/: demo_zsl42x_core_drv_flash.c
    ../../../../../examples/board/am42x_core/gpio/: demo_zsl42x_core_hw_gpio.c demo_zsl42x_core_hw_gpio_trigger.c demo_zsl42x_core_std_gpio.c demo_zsl42x_core_std_gpio_trigger.c
    ../../../../../examples/board/am42x_core/i2c/: demo_zsl42x_core_std_i2c_master_async.c demo_zsl42x_core_std_i2c_master_sync.c demo_zsl42x_core_std_i2c_slave_int.c
    ../../../../../examples/board/am42x_core/input_event/: demo_zsl42x_core_std_key_input_event.c
    ../../../../../examples/board/am42x_core/lcd/: demo_zsl42x_core_lcd.c
    ../../../../../examples/board/am42x_core/led/: demo_zsl42x_core_std_led.c
    ../../../../../examples/board/am42x_core/lptimer/: demo_zsl42x_core_std_lptim_timing_gate.c demo_zsl42x_core_std_lptim0_timing.c demo_zsl42x_core_std_lptim1_timing.c
    ../../../../../examples/board/am42x_core/lpuart/: demo_zsl42x_core_hw_lpuart_int.c demo_zsl42x_core_hw_lpuart_polling.c demo_zsl42x_core_hw_lpuart_rx_dma.c demo_zsl42x_core_hw_lpuart_tx_dma.c demo_zsl42x_core_std_lpuart_polling.c demo_zsl42x_core_std_lpuart_ringbuf.c
    ../../../../../examples/board/am42x_core/lvd/: demo_zsl42x_core_lvd_int.c demo_zsl42x_core_lvd_system_reset.c
    ../../../../../examples/board/am42x_core/microport_board/: demo_zsl42x_core_microport_ds1302.c demo_zsl42x_core_microport_rtc.c demo_zsl42x_core_microport_rx8025t.c
    ../../../../../examples/board/am42x_core/miniport_board/: demo_zsl42x_core_miniport_digitron.c demo_zsl42x_core_miniport_hc595_digitron.c demo_zsl42x_core_miniport_hc595_led.c demo_zsl42x_core_miniport_key.c demo_zsl42x_core_miniport_led.c demo_zsl42x_core_miniport_zlg72128.c
    ../../../../../examples/board/am42x_core/opa/: demo_zsl42x_core_opa_dac.c demo_zsl42x_core_opa_one.c
    ../../../../../examples/board/am42x_core/spi/: demo_zsl42x_core_hw_spi_master.c demo_zsl42x_core_std_spi_master_dma.c demo_zsl42x_core_std_spi_master_int.c
    ../../../../../examples/board/am42x_core/timer/: demo_zsl42x_core_hw_adtim_port_sw_brake.c demo_zsl42x_core_hw_adtim_swsync.c demo_zsl42x_core_hw_adtim_trig_adc_sqr.c demo_zsl42x_core_hw_adtim_vc_brake.c demo_zsl42x_core_hw_tim_cap.c demo_zsl42x_core_hw_tim_cmp_toggle.c demo_zsl42x_core_hw_tim_port_brake.c demo_zsl42x_core_hw_tim_pwm.c demo_zsl42x_core_hw_tim_pwm_dead.c demo_zsl42x_core_hw_tim_timing.c demo_zsl42x_core_hw_tim_trig_adc_sqr.c demo_zsl42x_core_hw_tim_vc_brake.c demo_zsl42x_core_std_tim0_cap.c demo_zsl42x_core_std_tim0_pwm.c demo_zsl42x_core_std_tim0_timing.c demo_zsl42x_core_std_tim1_cap.c demo_zsl42x_core_std_tim1_pwm.c demo_zsl42x_core_std_tim1_timing.c demo_zsl42x_core_std_tim2_cap.c demo_zsl42x_core_std_tim2_pwm.c demo_zsl42x_core_std_tim2_timing.c demo_zsl42x_core_std_tim3_cap.c demo_zsl42x_core_std_tim3_pwm.c demo_zsl42x_core_std_tim3_timing.c demo_zsl42x_core_std_tim4_cap.c demo_zsl42x_core_std_tim4_pwm.c demo_zsl42x_core_std_tim4_timing.c demo_zsl42x_core_std_tim5_cap.c demo_zsl42x_core_std_tim5_pwm.c demo_zsl42x_core_std_tim5_timing.c demo_zsl42x_core_std_tim6_cap.c demo_zsl42x_core_std_tim6_pwm.c demo_zsl42x_core_std_tim6_timing.c
    ../../../../../examples/board/am42x_core/trng/: demo_zsl42x_core_trng_generate.c
    ../../../../../examples/board/am42x_core/uart/: demo_zsl42x_core_hw_uart_int.c demo_zsl42x_core_hw_uart_polling.c demo_zsl42x_core_hw_uart_rx_dma.c demo_zsl42x_core_hw_uart_tx_dma.c demo_zsl42x_core_std_uart_polling.c demo_zsl42x_core_std_uart_ringbuf.c
    ../../../../../examples/board/am42x_core/vc/: demo_zsl42x_core_vc_int.c
    ../../../../../examples/board/am42x_core/wakeup/: demo_zsl42x_wake_up.c
    ../../../../../examples/board/am42x_core/wdt/: demo_zsl42x_core_hw_wdt.c demo_zsl42x_core_std_wdt.c
    ../../../../../examples/board/am42x_core/bootloader/: demo_zsl42x_core_single_application.c demo_zsl42x_core_double_uart_application.c
    ../../../../../examples/board/am42x_core/rtc/: demo_zsl42x_core_hw_rtc.c demo_zsl42x_core_std_rtc.c
    ../../../../../examples/board/am42x_core/lora/: demo_zsl42x_core_lora_cad_rx_tx.c demo_zsl42x_core_lora_channel_activity_detect.c demo_zsl42x_core_lora_rx_continuous.c demo_zsl42x_core_lora_rx_timeout.c demo_zsl42x_core_lora_tx.c
  group examples_components
    ../../../../../examples/components/drivers/: demo_ep24cxx.c demo_fm25clxx.c demo_fm175xx_cpu_card.c demo_fm175xx_fm11rf005m_opra.c demo_fm175xx_picca_halt.c demo_fm175xx_picca_lpcd_read_id.c demo_fm175xx_picca_read_block.c demo_fm175xx_picca_read_id.c demo_fm175xx_picca_val_operate.c demo_fm175xx_picca_write_block.c demo_fm175xx_piccb_read_id.c demo_gs200_baudrate.c demo_mk100.c demo_mx25xx.c demo_rs200.c demo_zlg9021_baudrate.c demo_zlg9021_led.c demo_zlg52810_baudrate.c demo_zm516x.c demo_zm516x_baudrate.c demo_zm516x_gpio.c demo_zm516x_key_led.c demo_zm516x_search.c demo_zsn603_auto_detect_test.c demo_zsn603_led_test.c demo_zsn603_picca_active_test.c demo_zsn603_piccb_active_test.c
  group examples_soc
    ../../../../../examples/soc/zlg/adc/: demo_zsl42x_hw_adc_dma.c demo_zsl42x_hw_adc_int.c demo_zsl42x_hw_multichan_adc.c
    ../../../../../examples/soc/zlg/adtimer/: demo_zsl42x_hw_adtim_port_sw_brake.c demo_zsl42x_hw_adtim_swsync.c demo_zsl42x_hw_adtim_trig_adc_sqr.c demo_zsl42x_hw_adtim_vc_brake.c
    ../../../../../examples/soc/zlg/aes/: demo_zsl42x_hw_aes_ency_decy.c
    ../../../../../examples/soc/zlg/clk/: demo_zsl42x_hw_clk.c
    ../../../../../examples/soc/zlg/dac/: demo_zsl42x_hw_dac_dma.c
    ../../../../../examples/soc/zlg/dma/: demo_zsl42x_drv_dma_m2m.c
    ../../../../../examples/soc/zlg/flash/: demo_zsl42x_drv_flash.c
    ../../../../../examples/soc/zlg/gpio/: demo_zsl42x_hw_gpio.c demo_zsl42x_hw_gpio_trigger.c
    ../../../../../examples/soc/zlg/lcd/: demo_zsl42x_hw_lcd.c
    ../../../../../examples/soc/zlg/lpuart/: demo_zsl42x_hw_lpuart_int.c demo_zsl42x_hw_lpuart_polling.c demo_zsl42x_hw_lpuart_rx_dma.c demo_zsl42x_hw_lpuart_tx_dma.c
    ../../../../../examples/soc/zlg/lvd/: demo_zsl42x_hw_lvd_int.c demo_zsl42x_hw_lvd_system_reset.c
    ../../../../../examples/soc/zlg/opa/: demo_zsl42x_hw_opa_dac.c demo_zsl42x_hw_opa.c
    ../../../../../examples/soc/zlg/spi/: demo_zsl42x_hw_spi_master.c
    ../../../../../examples/soc/zlg/timer/: demo_zsl42x_hw_tim_cap.c demo_zsl42x_hw_tim_cmp_toggle.c demo_zsl42x_hw_tim_port_brake.c demo_zsl42x_hw_tim_pwm.c demo_zsl42x_hw_tim_pwm_dead.c demo_zsl42x_hw_tim_timing.c demo_zsl42x_hw_tim_trig_adc_sqr.c demo_zsl42x_hw_tim_vc_brake.c
    ../../../../../examples/soc/zlg/trng/: demo_zsl42x_hw_trng_generate.c
    ../../../../../examples/soc/zlg/uart/: demo_zsl42x_hw_uart_int.c demo_zsl42x_hw_uart_polling.c demo_zsl42x_hw_uart_rx_dma.c demo_zsl42x_hw_uart_tx_dma.c
    ../../../../../examples/soc/zlg/vc/: demo_zsl42x_hw_vc_int.c
    ../../../../../examples/soc/zlg/wdg/: demo_zsl42x_hw_wdt.c
    ../../../../../examples/soc/zlg/rtc/: demo_zsl42x_hw_rtc.c
  group examples_std
    ../../../../../examples/std/adc/: demo_std_adc.c demo_std_adc_ntc.c demo_std_multichan_adc.c
    ../../../../../examples/std/buzzer/: demo_std_buzzer.c
    ../../../../../examples/std/cap/: demo_std_timer_cap.c
    ../../../../../examples/std/crc/: demo_std_crc.c
    ../../../../../examples/std/dac/: demo_std_dac.c
    ../../../../../examples/std/delay/: demo_std_delay.c
    ../../../../../examples/std/digitron/: demo_std_digitron_60s_counting.c demo_std_digitron_temp.c
    ../../../../../examples/std/gpio/: demo_std_gpio.c demo_std_gpio_trigger.c
    ../../../../../examples/std/hc595/: demo_std_hc595_led.c
    ../../../../../examples/std/i2c/: demo_std_i2c_lm75.c demo_std_i2c_master_async.c demo_std_i2c_master_sync.c demo_std_i2c_slave.c demo_std_i2c_slave_subaddr.c
    ../../../../../examples/std/input/: demo_std_4key.c demo_std_key.c demo_std_key_digitron.c demo_std_key_digitron_rngbuf.c
    ../../../../../examples/std/led/: demo_std_led.c demo_std_led_water_light.c
    ../../../../../examples/std/nvram/: demo_std_nvram.c
    ../../../../../examples/std/pwm/: demo_std_timer_pwm.c
    ../../../../../examples/std/rtc/: demo_std_rtc.c
    ../../../../../examples/std/softimer/: demo_std_softimer.c
    ../../../../../examples/std/spi/: demo_std_spi_flash.c demo_std_spi_master.c demo_std_spi_slave.c
    ../../../../../examples/std/timer/: demo_std_timer_timing.c
    ../../../../../examples/std/uart/: demo_std_uart_polling.c demo_std_uart_ringbuf.c demo_std_uart_rs485.c
    ../../../../../examples/std/wdt/: demo_std_wdt.c
    ../../../../../examples/components/bootloader/: demo_std_double_application.c
  group startup
    ../startup/: am_zsl42x_armcc_startup.s
  group user_code
    ../user_code/: main.c
  group user_config
    ../user_config/: am_prj_config.h am_prj_config.c am_board.c
    ../user_config/am_bootconf_usrcfg/: am_appconf_zsl42x_clk.c am_appconf_double_zsl42x.c
    ../user_config/am_servconf_usrcfg/: am_servconf_event_input.c am_servconf_nvram.c
    ../user_config/am_hwconf_usrcfg/: am_hwconf_buzzer_pwm.c am_hwconf_debug_uart.c am_hwconf_zsl42x_adc.c am_hwconf_zsl42x_aes.c am_hwconf_zsl42x_arm_nvic.c am_hwconf_zsl42x_clk.c am_hwconf_zsl42x_crc.c am_hwconf_zsl42x_dac.c am_hwconf_zsl42x_dma.c am_hwconf_zsl42x_gpio.c am_hwconf_zsl42x_i2c.c am_hwconf_zsl42x_i2c_slv.c am_hwconf_zsl42x_lcd.c am_hwconf_zsl42x_led_gpio.c am_hwconf_zsl42x_lptim.c am_hwconf_zsl42x_lpuart.c am_hwconf_zsl42x_lvd.c am_hwconf_zsl42x_opa.c am_hwconf_zsl42x_pca.c am_hwconf_zsl42x_pcnt.c am_hwconf_zsl42x_rtc.c am_hwconf_zsl42x_spi_dma.c am_hwconf_zsl42x_spi_int.c am_hwconf_zsl42x_spi_poll.c am_hwconf_zsl42x_systick.c am_hwconf_zsl42x_tim_cap.c am_hwconf_zsl42x_tim_pwm.c am_hwconf_zsl42x_tim_timing.c am_hwconf_zsl42x_trng.c am_hwconf_zsl42x_uart.c am_hwconf_zsl42x_vc.c am_hwconf_zsl42x_wdt.c am_hwconf_key_gpio.c am_hwconf_microport_ds1302.c am_hwconf_microport_rtc.c am_hwconf_microport_rx8025t.c am_hwconf_miniport_595.c am_hwconf_miniport_key.c am_hwconf_miniport_led.c am_hwconf_miniport_view.c am_hwconf_miniport_view_key.c am_hwconf_miniport_zlg72128.c am_hwconf_sensor_hts221.c am_hwconf_system_tick_softimer.c am_hwconf_zsl42x_lora_spi0.c am_hwconf_zsl42x_lpsoftimer.c
  group bootloader
    ../../../../../components/bootloader/source/arch/arm/: am_arm_boot.c
    ../../../../../components/bootloader/source/drivers/: am_boot.c am_boot_enter_check_key.c am_boot_enter_check_uart.c am_boot_enter_check_uart_cmd.c am_boot_firmware_flash.c am_boot_firmware_recv_uart.c am_boot_mem_flash.c am_boot_msg_flag.c am_boot_serial_uart.c
target release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32L196PCTA HDSC
  pack: HDSC.HC32L19X.1.0.0
  cpu: as above
  output: demo_am42x_core_application +hex
  AfterMake: fromelf --bincombined -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG,AM_CORTEX_M0
  c include: ..\..\..\..\..\3rdparty/CMSIS/Include;..\..\..\..\..\arch/arm/include;..\..\..\..\..\components/drivers/include;..\..\..\..\..\components/libc/armlib_adapter/include;..\..\..\..\..\components/libc/microlib_adapter/include;..\..\..\..\..\components/service/include;..\..\..\..\..\components/util/include;..\user_code;..\user_config;..\user_config/am_hwconf_usrcfg;..\user_config/am_servconf_usrcfg;..\..\..\..\..\board/bsp_common/include;..\..\..\..\..\examples/components;..\..\..\..\..\examples/soc/zlg;..\..\..\..\..\examples/std;..\..\..\..\..\examples\board\am42x_core;..\..\..\..\..\interface;..\..\..\..\..\soc\zlg\zsl42x;..\..\..\..\..\soc\zlg\drivers\include\adc;..\..\..\..\..\soc\zlg\drivers\include\adtim;..\..\..\..\..\soc\zlg\drivers\include\aes;..\..\..\..\..\soc\zlg\drivers\include\clk;..\..\..\..\..\soc\zlg\drivers\include\clktrim;..\..\..\..\..\soc\zlg\drivers\include\crc;..\..\..\..\..\soc\zlg\drivers\include\dac;..\..\..\..\..\soc\zlg\drivers\include\dma;..\..\..\..\..\soc\zlg\drivers\include\flash;..\..\..\..\..\soc\zlg\drivers\include\gpio;..\..\..\..\..\soc\zlg\drivers\include\i2c;..\..\..\..\..\soc\zlg\drivers\include\lcd;..\..\..\..\..\soc\zlg\drivers\include\lpmode;..\..\..\..\..\soc\zlg\drivers\include\lptim;..\..\..\..\..\soc\zlg\drivers\include\lpuart;..\..\..\..\..\soc\zlg\drivers\include\lvd;..\..\..\..\..\soc\zlg\drivers\include\opa;..\..\..\..\..\soc\zlg\drivers\include\pca;..\..\..\..\..\soc\zlg\drivers\include\pcnt;..\..\..\..\..\soc\zlg\drivers\include\ram;..\..\..\..\..\soc\zlg\drivers\include\rcc;..\..\..\..\..\soc\zlg\drivers\include\rtc;..\..\..\..\..\soc\zlg\drivers\include\spi;..\..\..\..\..\soc\zlg\drivers\include\tim;..\..\..\..\..\soc\zlg\drivers\include\trng;..\..\..\..\..\soc\zlg\drivers\include\uart;..\..\..\..\..\soc\zlg\drivers\include\vc;..\..\..\..\..\soc\zlg\drivers\include\wdt;..\..\..\..\..\soc\zlg\drivers\include\bootloader;..\user_config\am_bootconf_usrcfg;..\..\..\..\..\examples\components\bootloader;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\bootloader\include\arch\arm;..\..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool;..\..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool\drivers;..\..\..\..\..\components\bootloader\include\core;..\..\..\..\..\components\bootloader\include\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\demo_am42x_core_application.sct

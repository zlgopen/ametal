# Keil uVision project demo_amf07x_core_application.uvprojx, settings and files
target debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F072PATA HDSC
  pack: HDSC.HC32F072.1.0.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: demo_amf07x_core_application +hex
  AfterMake: fromelf --bincombined -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M0
  c include: ..\..\..\..\..\3rdparty/CMSIS/Include;..\..\..\..\..\arch/arm/include;..\..\..\..\..\components/drivers/include;..\..\..\..\..\components/libc/armlib_adapter/include;..\..\..\..\..\components/libc/microlib_adapter/include;..\..\..\..\..\components/service/include;..\..\..\..\..\components/util/include;..\user_code;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config/am_servconf_usrcfg;..\..\..\..\..\board/bsp_common/include;..\..\..\..\..\examples/components;..\..\..\..\..\examples/soc/hdsc;..\..\..\..\..\examples/std;..\..\..\..\..\examples\board\hc32f07x_core;..\..\..\..\..\interface;..\..\..\..\..\soc\hdsc\hc32;..\..\..\..\..\soc\hdsc\drivers\include\adc;..\..\..\..\..\soc\hdsc\drivers\include\adtim;..\..\..\..\..\soc\hdsc\drivers\include\aes;..\..\..\..\..\soc\hdsc\drivers\include\clk;..\..\..\..\..\soc\hdsc\drivers\include\clktrim;..\..\..\..\..\soc\hdsc\drivers\include\crc;..\..\..\..\..\soc\hdsc\drivers\include\dac;..\..\..\..\..\soc\hdsc\drivers\include\dma;..\..\..\..\..\soc\hdsc\drivers\include\flash;..\..\..\..\..\soc\hdsc\drivers\include\gpio;..\..\..\..\..\soc\hdsc\drivers\include\i2c;..\..\..\..\..\soc\hdsc\drivers\include\lcd;..\..\..\..\..\soc\hdsc\drivers\include\lpmode;..\..\..\..\..\soc\hdsc\drivers\include\lptim;..\..\..\..\..\soc\hdsc\drivers\include\lpuart;..\..\..\..\..\soc\hdsc\drivers\include\lvd;..\..\..\..\..\soc\hdsc\drivers\include\opa;..\..\..\..\..\soc\hdsc\drivers\include\pca;..\..\..\..\..\soc\hdsc\drivers\include\pcnt;..\..\..\..\..\soc\hdsc\drivers\include\ram;..\..\..\..\..\soc\hdsc\drivers\include\rcc;..\..\..\..\..\soc\hdsc\drivers\include\rtc;..\..\..\..\..\soc\hdsc\drivers\include\spi;..\..\..\..\..\soc\hdsc\drivers\include\tim;..\..\..\..\..\soc\hdsc\drivers\include\trng;..\..\..\..\..\soc\hdsc\drivers\include\uart;..\..\..\..\..\soc\hdsc\drivers\include\vc;..\..\..\..\..\soc\hdsc\drivers\include\wdt;..\..\..\..\..\components\usb\include;..\..\..\..\..\components\usb\device\class\include;..\..\..\..\..\components\usb\device\common\include;..\..\..\..\..\components\usb\device;..\..\..\..\..\components\usb\osa;..\..\..\..\..\soc\hdsc\hc32f07x;..\..\..\..\..\soc\hdsc\drivers\include\can;..\..\..\..\..\soc\hdsc\drivers\include\hdiv;..\..\..\..\..\soc\hdsc\drivers\include\i2s;..\..\..\..\..\soc\hdsc\drivers\include\usbd;..\..\..\..\..\soc\hdsc\drivers\include\cts;..\..\..\..\..\soc\hdsc\drivers\include\bootloader;..\user_config\am_bootconf_usrcfg;..\..\..\..\..\examples\components\bootloader;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\bootloader\include\arch\arm;..\..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool;..\..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool\drivers;..\..\..\..\..\components\bootloader\include\core;..\..\..\..\..\components\bootloader\include\drivers
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\demo_amf07x_core_application.sct
  group bsp_common
    ../../../../bsp_common/source/: am_bsp_armlib.c am_bsp_delay_timer.c am_bsp_isr_defer_pendsv.c am_bsp_microlib.c am_bsp_system_heap.c
  group arm
    ../../../../../arch/arm/source/: am_arm_nvic.c am_arm_nvic_armcc.s am_arm_systick.c
  group drivers
    ../../../../../components/drivers/source/digitron_key/: am_zlg72128_std.c zlg72128.c zlg72128_platform.c
    ../../../../../components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../../../../../components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../../../../../components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../../../../../components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../../../../../components/drivers/source/fm175xx/: am_fm175xx_ant.c
    ../../../../../components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../../../../../components/drivers/source/led/: am_led_gpio.c am_led_hc595.c
    ../../../../../components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../../../../../components/drivers/source/temperature/: am_temp_lm75.c
    ../../../../../components/drivers/source/miniport/: am_miniport_view_key.c am_miniport_view_key_595.c
    ../../../../../components/drivers/source/sensor/: am_sensor_hts221.c
  group libc
    ../../../../../components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../../../../../components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../../../../../components/service/source/: am_adc.c am_buzzer_dev.c am_dac.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_category_input.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_uart.c am_uart_rngbuf.c am_timer.c am_sensor.c
  group util
    ../../../../../components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c
  group soc
    ../../../../../soc/hdsc/drivers/source/adtim/: am_hc32_adtim_cap.c am_hc32_adtim_pwm.c am_hc32_adtim_timing.c
    ../../../../../soc/hdsc/drivers/source/adtim/hw/: amhw_hc32_adtim.c
    ../../../../../soc/hdsc/drivers/source/aes/: am_hc32_aes.c
    ../../../../../soc/hdsc/drivers/source/clktrim/: am_hc32_clktrim.c am_hc32f07x_clktrim.c
    ../../../../../soc/hdsc/drivers/source/crc/: am_hc32_crc.c
    ../../../../../soc/hdsc/drivers/source/dma/: am_hc32_dma.c
    ../../../../../soc/hdsc/drivers/source/gpio/hw/: amhw_hc32_gpio.c
    ../../../../../soc/hdsc/drivers/source/gpio/: am_hc32_gpio.c
    ../../../../../soc/hdsc/drivers/source/i2c/: am_hc32_i2c.c am_hc32_i2c_slv.c
    ../../../../../soc/hdsc/drivers/source/lcd/: am_hc32_lcd.c
    ../../../../../soc/hdsc/drivers/source/lpuart/hw/: amhw_hc32_lpuart.c
    ../../../../../soc/hdsc/drivers/source/lpuart/: am_hc32_lpuart.c
    ../../../../../soc/hdsc/drivers/source/lvd/: am_hc32_lvd.c
    ../../../../../soc/hdsc/drivers/source/pca/: am_hc32_pca.c
    ../../../../../soc/hdsc/drivers/source/pcnt/: am_hc32_pcnt.c
    ../../../../../soc/hdsc/drivers/source/ram/: am_hc32_ram.c
    ../../../../../soc/hdsc/drivers/source/rcc/hw/: amhw_hc32_rcc_reset.c amhw_hc32_rcc.c amhw_hc32f07x_rcc.c
    ../../../../../soc/hdsc/drivers/source/rtc/: am_hc32_rtc.c
    ../../../../../soc/hdsc/drivers/source/spi/: am_hc32_spi_dma.c am_hc32_spi_int.c am_hc32_spi_poll.c
    ../../../../../soc/hdsc/drivers/source/tim/: am_hc32_tim_cap.c am_hc32_tim_pwm.c am_hc32_tim_timing.c
    ../../../../../soc/hdsc/drivers/source/trng/: am_hc32_trng.c
    ../../../../../soc/hdsc/drivers/source/uart/hw/: amhw_hc32_uart.c
    ../../../../../soc/hdsc/drivers/source/uart/: am_hc32_uart.c
    ../../../../../soc/hdsc/drivers/source/wdt/: am_hc32_wdt.c
    ../../../../../components/usb/: am_usbd_lib_m0.lib
    ../../../../../soc/hdsc/drivers/source/vc/: am_hc32_vc.c
    ../../../../../soc/hdsc/drivers/source/can/: am_hc32f07x_can.c
    ../../../../../soc/hdsc/drivers/source/clk/: am_hc32f07x_clk.c
    ../../../../../soc/hdsc/drivers/source/dac/: am_hc32f07x_dac.c
    ../../../../../soc/hdsc/drivers/source/opa/: am_hc32f07x_opa.c
    ../../../../../soc/hdsc/drivers/source/hdiv/: am_hc32f07x_hdiv.c
    ../../../../../soc/hdsc/drivers/source/i2s/: am_hc32f07x_i2s.c
    ../../../../../soc/hdsc/drivers/source/usbd/: am_hc32f07x_usbd.c
    ../../../../../soc/hdsc/drivers/source/flash/: am_hc32f07x_flash.c
    ../../../../../soc/hdsc/drivers/source/cts/: am_hc32f07x_cts.c
    ../../../../../soc/hdsc/drivers/source/adc/: am_hc32f07x_adc.c
    ../../../../../soc/hdsc/drivers/source/bootloader/: am_hc32f07x_boot_flash.c
  group examples_board
    ../../../../../examples/board/hc32f07x_core/adc/: demo_hc32f07x_core_hw_adc_dma.c demo_hc32f07x_core_hw_adc_int.c demo_hc32f07x_core_hw_multichan_adc.c demo_hc32f07x_core_std_adc.c demo_hc32f07x_core_std_multichan_adc.c
    ../../../../../examples/board/hc32f07x_core/aes/: demo_hc32f07x_core_aes_ency_decy.c
    ../../../../../examples/board/hc32f07x_core/can/: demo_hc32f07x_std_can.c
    ../../../../../examples/board/hc32f07x_core/clk/: demo_hc32f07x_core_hw_clk.c
    ../../../../../examples/board/hc32f07x_core/crc/: demo_hc32f07x_core_std_crc.c
    ../../../../../examples/board/hc32f07x_core/dac/: demo_hc32f07x_core_hw_dac_dma.c demo_hc32f07x_core_std_dac.c
    ../../../../../examples/board/hc32f07x_core/delay/: demo_hc32f07x_core_std_delay.c
    ../../../../../examples/board/hc32f07x_core/dma/: demo_hc32f07x_core_drv_dma_m2m.c
    ../../../../../examples/board/hc32f07x_core/gpio/: demo_hc32f07x_core_hw_gpio.c demo_hc32f07x_core_hw_gpio_trigger.c demo_hc32f07x_core_std_gpio.c demo_hc32f07x_core_std_gpio_trigger.c
    ../../../../../examples/board/hc32f07x_core/hdiv/: demo_hc32f07x_hw_hdiv.c
    ../../../../../examples/board/hc32f07x_core/i2c/: demo_hc32f07x_core_std_i2c_master_async.c demo_hc32f07x_core_std_i2c_master_sync.c demo_hc32f07x_core_std_i2c_slave_int.c
    ../../../../../examples/board/hc32f07x_core/lcd/: demo_hc32f07x_core_lcd.c
    ../../../../../examples/board/hc32f07x_core/lpuart/: demo_hc32f07x_core_hw_lpuart_int.c demo_hc32f07x_core_hw_lpuart_polling.c demo_hc32f07x_core_hw_lpuart_rx_dma.c demo_hc32f07x_core_hw_lpuart_tx_dma.c demo_hc32f07x_core_std_lpuart_polling.c demo_hc32f07x_core_std_lpuart_ringbuf.c
    ../../../../../examples/board/hc32f07x_core/lvd/: demo_hc32f07x_core_lvd_int.c demo_hc32f07x_core_lvd_system_reset.c
    ../../../../../examples/board/hc32f07x_core/opa/: demo_hc32f07x_core_opa_dac.c demo_hc32f07x_core_opa_one.c
    ../../../../../examples/board/hc32f07x_core/spi/: demo_hc32f07x_core_hw_spi_master.c demo_hc32f07x_core_std_spi_master_dma.c demo_hc32f07x_core_std_spi_master_int.c
    ../../../../../examples/board/hc32f07x_core/timer/: demo_hc32f07x_core_hw_adtim_port_sw_brake.c demo_hc32f07x_core_hw_adtim_swsync.c demo_hc32f07x_core_hw_adtim_trig_adc_sqr.c demo_hc32f07x_core_hw_adtim_vc_brake.c demo_hc32f07x_core_hw_tim_cap.c demo_hc32f07x_core_hw_tim_cmp_toggle.c demo_hc32f07x_core_hw_tim_port_brake.c demo_hc32f07x_core_hw_tim_pwm.c demo_hc32f07x_core_hw_tim_pwm_dead.c demo_hc32f07x_core_hw_tim_timing.c demo_hc32f07x_core_hw_tim_trig_adc_sqr.c demo_hc32f07x_core_hw_tim_vc_brake.c demo_hc32f07x_core_std_tim0_cap.c demo_hc32f07x_core_std_tim0_pwm.c demo_hc32f07x_core_std_tim0_timing.c demo_hc32f07x_core_std_tim1_cap.c demo_hc32f07x_core_std_tim1_pwm.c demo_hc32f07x_core_std_tim1_timing.c demo_hc32f07x_core_std_tim2_cap.c demo_hc32f07x_core_std_tim2_pwm.c demo_hc32f07x_core_std_tim2_timing.c demo_hc32f07x_core_std_tim3_cap.c demo_hc32f07x_core_std_tim3_pwm.c demo_hc32f07x_core_std_tim3_timing.c demo_hc32f07x_core_std_tim4_cap.c demo_hc32f07x_core_std_tim4_pwm.c demo_hc32f07x_core_std_tim4_timing.c demo_hc32f07x_core_std_tim5_cap.c demo_hc32f07x_core_std_tim5_pwm.c demo_hc32f07x_core_std_tim5_timing.c demo_hc32f07x_core_std_tim6_cap.c demo_hc32f07x_core_std_tim6_pwm.c demo_hc32f07x_core_std_tim6_timing.c
    ../../../../../examples/board/hc32f07x_core/trng/: demo_hc32f07x_core_trng_generate.c
    ../../../../../examples/board/hc32f07x_core/uart/: demo_hc32f07x_core_hw_uart_int.c demo_hc32f07x_core_hw_uart_polling.c demo_hc32f07x_core_hw_uart_rx_dma.c demo_hc32f07x_core_hw_uart_tx_dma.c demo_hc32f07x_core_std_uart_polling.c demo_hc32f07x_core_std_uart_ringbuf.c
    ../../../../../examples/board/hc32f07x_core/vc/: demo_hc32f07x_core_vc_int.c
    ../../../../../examples/board/hc32f07x_core/wdt/: demo_hc32f07x_core_hw_wdt.c demo_hc32f07x_core_std_wdt.c
    ../../../../../examples/board/hc32f07x_core/rtc/: demo_hc32f07x_core_std_rtc.c
    ../../../../../examples/board/hc32f07x_core/usbd/: demo_hc32f07x_core_usbd_mouse.c
    ../../../../../examples/board/hc32f07x_core/flash/: demo_hc32f07x_core_drv_flash.c
    ../../../../../examples/board/hc32f07x_core/ram/: demo_hc32f07x_core_ram.c
    ../../../../../examples/board/hc32f07x_core/clktrim/: demo_hc32f07x_core_clktrim.c
    ../../../../../examples/board/hc32f07x_core/cts/: demo_hc32f07x_core_cts.c
    ../../../../../examples/board/hc32f07x_core/i2s/: demo_hc32f07x_core_hw_i2s.c
    ../../../../../examples/board/hc32f07x_core/led/: demo_hc32f07x_core_std_led.c
    ../../../../../examples/board/hc32f07x_core/input_event/: demo_hc32f07x_core_std_key_input_event.c
    ../../../../../examples/board/hc32f07x_core/pca/: demo_hc32f07x_core_drv_pca_16bit_pwm.c demo_hc32f07x_core_drv_pca_8bit_pwm.c
    ../../../../../examples/board/hc32f07x_core/bootloader/: demo_hc32f07x_core_double_uart_application.c demo_hc32f07x_core_single_application.c
  group examples_components
    ../../../../../components/drivers/source/rtc/: am_ds1302.c am_pcf85063.c am_rx8025sa.c am_rx8025t.c
  group examples_soc
    ../../../../../examples/soc/hdsc/adc/: demo_hc32_hw_adc_dma.c demo_hc32_hw_adc_int.c demo_hc32_hw_multichan_adc.c
    ../../../../../examples/soc/hdsc/adtimer/: demo_hc32_hw_adtim_port_sw_brake.c demo_hc32_hw_adtim_swsync.c demo_hc32_hw_adtim_trig_adc_sqr.c demo_hc32_hw_adtim_vc_brake.c
    ../../../../../examples/soc/hdsc/aes/: demo_hc32_hw_aes_ency_decy.c
    ../../../../../examples/soc/hdsc/clk/: demo_hc32_hw_clk.c
    ../../../../../examples/soc/hdsc/dac/: demo_hc32_hw_dac_dma.c demo_hc32f07x_hw_dac_dma.c
    ../../../../../examples/soc/hdsc/dma/: demo_hc32_drv_dma_m2m.c
    ../../../../../examples/soc/hdsc/gpio/: demo_hc32_hw_gpio.c demo_hc32_hw_gpio_trigger.c
    ../../../../../examples/soc/hdsc/lcd/: demo_hc32_hw_lcd.c
    ../../../../../examples/soc/hdsc/lpuart/: demo_hc32_hw_lpuart_int.c demo_hc32_hw_lpuart_polling.c demo_hc32_hw_lpuart_rx_dma.c demo_hc32_hw_lpuart_tx_dma.c
    ../../../../../examples/soc/hdsc/lvd/: demo_hc32_hw_lvd_int.c demo_hc32_hw_lvd_system_reset.c
    ../../../../../examples/soc/hdsc/spi/: demo_hc32_hw_spi_master.c
    ../../../../../examples/soc/hdsc/timer/: demo_hc32_hw_tim_cap.c demo_hc32_hw_tim_cmp_toggle.c demo_hc32_hw_tim_port_brake.c demo_hc32_hw_tim_pwm.c demo_hc32_hw_tim_pwm_dead.c demo_hc32_hw_tim_timing.c demo_hc32_hw_tim_trig_adc_sqr.c demo_hc32_hw_tim_vc_brake.c
    ../../../../../examples/soc/hdsc/trng/: demo_hc32_hw_trng_generate.c
    ../../../../../examples/soc/hdsc/uart/: demo_hc32_hw_uart_int.c demo_hc32_hw_uart_polling.c demo_hc32_hw_uart_rx_dma.c demo_hc32_hw_uart_tx_dma.c
    ../../../../../examples/soc/hdsc/vc/: demo_hc32_hw_vc_int.c
    ../../../../../examples/soc/hdsc/wdg/: demo_hc32_hw_wdt.c
    ../../../../../examples/soc/hdsc/opa/: demo_hc32f07x_hw_opa_one.c demo_hc32_hw_opa.c demo_hc32f07x_hw_opa_dac.c
    ../../../../../examples/soc/hdsc/flash/: demo_hc32f07x_drv_flash .c
  group examples_std
    ../../../../../examples/std/adc/: demo_std_adc.c demo_std_adc_ntc.c demo_std_multichan_adc.c
    ../../../../../examples/std/buzzer/: demo_std_buzzer.c
    ../../../../../examples/std/cap/: demo_std_timer_cap.c
    ../../../../../examples/std/crc/: demo_std_crc.c
    ../../../../../examples/std/dac/: demo_std_dac.c
    ../../../../../examples/std/delay/: demo_std_delay.c
    ../../../../../examples/std/gpio/: demo_std_gpio.c demo_std_gpio_trigger.c
    ../../../../../examples/std/i2c/: demo_std_i2c_lm75.c demo_std_i2c_master_async.c demo_std_i2c_master_sync.c demo_std_i2c_slave.c demo_std_i2c_slave_subaddr.c
    ../../../../../examples/std/led/: demo_std_led.c demo_std_led_water_light.c
    ../../../../../examples/std/pwm/: demo_std_timer_pwm.c
    ../../../../../examples/std/softimer/: demo_std_softimer.c
    ../../../../../examples/std/spi/: demo_std_spi_flash.c demo_std_spi_master.c demo_std_spi_slave.c
    ../../../../../examples/std/timer/: demo_std_timer_timing.c
    ../../../../../examples/std/uart/: demo_std_uart_polling.c demo_std_uart_ringbuf.c demo_std_uart_rs485.c
    ../../../../../examples/std/wdt/: demo_std_wdt.c
    ../../../../../examples/std/rtc/: demo_std_rtc.c
    ../../../../../examples/std/input/: demo_std_4key.c demo_std_key.c demo_std_key_digitron.c demo_std_key_digitron_rngbuf.c
    ../../../../../examples/std/hc595/: demo_std_hc595_led.c
    ../../../../../examples/std/digitron/: demo_std_digitron_60s_counting.c demo_std_digitron_temp.c
    ../../../../../examples/std/nvram/: demo_std_nvram.c
    ../../../../../examples/std/sensor/hts221/: demo_std_hts221.c demo_std_hts221_int.c
    ../../../../../examples/std/sensor/bmp280/: demo_std_bmp280.c
    ../../../../../examples/std/sensor/bme280/: demo_std_bme280.c
    ../../../../../examples/std/sensor/lps22hb/: demo_std_lps22hb.c demo_std_lps22hb_int.c
    ../../../../../examples/std/sensor/bh1730fvc/: demo_std_bh1730fvc.c
    ../../../../../examples/std/sensor/bma253/: demo_std_bma253.c demo_std_bma253_int.c
    ../../../../../examples/std/sensor/lis3mdl/: demo_std_lis3mdl.c demo_std_lis3mdl_int.c
    ../../../../../examples/std/sensor/lsm6dsl/: demo_std_lsm6dsl.c demo_std_lsm6dsl_int.c
    ../../../../../examples/std/sensor/shtc1/: demo_std_shtc1.c
    ../../../../../examples/std/can/: demo_std_can.c
    ../../../../../examples/components/bootloader/: demo_std_double_application.c
  group startup
    ../startup/: am_hc32f07x_armcc_startup.s
  group user_code
    ../user_code/: main.c
  group user_config
    ../user_config/: am_board.c am_prj_config.c
    ../user_config/am_hwconf_usrcfg/: am_hwconf_buzzer_pwm.c am_hwconf_debug_uart.c am_hwconf_key_gpio.c am_hwconf_system_tick_softimer.c am_hwconf_hc32f07x_adc.c am_hwconf_hc32f07x_aes.c am_hwconf_hc32f07x_arm_nvic.c am_hwconf_hc32f07x_clk.c am_hwconf_hc32f07x_crc.c am_hwconf_hc32f07x_dac.c am_hwconf_hc32f07x_dma.c am_hwconf_hc32f07x_gpio.c am_hwconf_hc32f07x_i2c.c am_hwconf_hc32f07x_i2c_slv.c am_hwconf_hc32f07x_lcd.c am_hwconf_hc32f07x_led_gpio.c am_hwconf_hc32f07x_lpuart.c am_hwconf_hc32f07x_lvd.c am_hwconf_hc32f07x_opa.c am_hwconf_hc32f07x_pca.c am_hwconf_hc32f07x_rtc.c am_hwconf_hc32f07x_spi_dma.c am_hwconf_hc32f07x_spi_int.c am_hwconf_hc32f07x_spi_poll.c am_hwconf_hc32f07x_systick.c am_hwconf_hc32f07x_tim_cap.c am_hwconf_hc32f07x_tim_pwm.c am_hwconf_hc32f07x_tim_timing.c am_hwconf_hc32f07x_trng.c am_hwconf_hc32f07x_uart.c am_hwconf_hc32f07x_vc.c am_hwconf_hc32f07x_wdt.c am_hwconf_hc32f07x_can.c am_hwconf_hc32f07x_usb_mouse.c
    ../user_config/am_servconf_usrcfg/: am_servconf_event_input.c am_servconf_nvram.c
    ../user_config/am_bootconf_usrcfg/: am_appconf_double_hc32f07x.c am_appconf_hc32f07x_clk.c
  group bootloader
    ../../../../../components/bootloader/source/arch/arm/: am_arm_boot.c
    ../../../../../components/bootloader/source/drivers/: am_boot.c am_boot_enter_check_key.c am_boot_enter_check_uart.c am_boot_enter_check_uart_cmd.c am_boot_firmware_flash.c am_boot_firmware_recv_uart.c am_boot_mem_flash.c am_boot_msg_flag.c am_boot_serial_uart.c
target release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F072PATA HDSC
  pack: HDSC.HC32F072.1.0.0
  cpu: as above
  output: template_amf07x_core +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M0
  c include: ..\..\..\..\..\3rdparty/CMSIS/Include;..\..\..\..\..\arch/arm/include;..\..\..\..\..\components/drivers/include;..\..\..\..\..\components/libc/armlib_adapter/include;..\..\..\..\..\components/libc/microlib_adapter/include;..\..\..\..\..\components/service/include;..\..\..\..\..\components/util/include;..\user_code;..\user_config;..\user_config/am_hwconf_usrcfg;..\user_config/am_servconf_usrcfg;..\..\..\..\..\board/bsp_common/include;..\..\..\..\..\examples/components;..\..\..\..\..\examples/soc/hdsc;..\..\..\..\..\examples/std;..\..\..\..\..\examples\board\hc32f07x_core;..\..\..\..\..\interface;..\..\..\..\..\soc\hdsc\hc32;..\..\..\..\..\soc\hdsc\drivers\include\adc;..\..\..\..\..\soc\hdsc\drivers\include\adtim;..\..\..\..\..\soc\hdsc\drivers\include\aes;..\..\..\..\..\soc\hdsc\drivers\include\clk;..\..\..\..\..\soc\hdsc\drivers\include\clktrim;..\..\..\..\..\soc\hdsc\drivers\include\crc;..\..\..\..\..\soc\hdsc\drivers\include\dac;..\..\..\..\..\soc\hdsc\drivers\include\dma;..\..\..\..\..\soc\hdsc\drivers\include\flash;..\..\..\..\..\soc\hdsc\drivers\include\gpio;..\..\..\..\..\soc\hdsc\drivers\include\i2c;..\..\..\..\..\soc\hdsc\drivers\include\lcd;..\..\..\..\..\soc\hdsc\drivers\include\lpmode;..\..\..\..\..\soc\hdsc\drivers\include\lptim;..\..\..\..\..\soc\hdsc\drivers\include\lpuart;..\..\..\..\..\soc\hdsc\drivers\include\lvd;..\..\..\..\..\soc\hdsc\drivers\include\opa;..\..\..\..\..\soc\hdsc\drivers\include\pca;..\..\..\..\..\soc\hdsc\drivers\include\pcnt;..\..\..\..\..\soc\hdsc\drivers\include\ram;..\..\..\..\..\soc\hdsc\drivers\include\rcc;..\..\..\..\..\soc\hdsc\drivers\include\rtc;..\..\..\..\..\soc\hdsc\drivers\include\spi;..\..\..\..\..\soc\hdsc\drivers\include\tim;..\..\..\..\..\soc\hdsc\drivers\include\trng;..\..\..\..\..\soc\hdsc\drivers\include\uart;..\..\..\..\..\soc\hdsc\drivers\include\vc;..\..\..\..\..\soc\hdsc\drivers\include\wdt;..\..\..\..\..\components\usb\include;..\..\..\..\..\components\usb\device\class\include;..\..\..\..\..\components\usb\device\common\include;..\..\..\..\..\components\usb\device;..\..\..\..\..\components\usb\osa;..\..\..\..\..\soc\hdsc\hc32f07x;..\..\..\..\..\soc\hdsc\drivers\include\can;..\..\..\..\..\soc\hdsc\drivers\include\hdiv;..\..\..\..\..\soc\hdsc\drivers\include\i2s;..\..\..\..\..\soc\hdsc\drivers\include\usbd;..\..\..\..\..\soc\hdsc\drivers\include\cts
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000

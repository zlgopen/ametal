# Keil uVision project ZLG_Thermometer.uvprojx, settings and files
target debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L136.1.0.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: zlg_thermometer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M0 HC32X3X HC32L136
  c include: ..\..\..\..\3rdparty/CMSIS/Include;..\..\..\..\arch/arm/include;..\..\..\..\components/drivers/include;..\..\..\..\components/libc/armlib_adapter/include;..\..\..\..\components/libc/microlib_adapter/include;..\..\..\..\components/service/include;..\..\..\..\components/util/include;..\user_code;..\user_config;..\user_config/am_hwconf_usrcfg;..\user_config/am_servconf_usrcfg;..\..\..\..\board/bsp_common/include;..\..\..\..\examples/components;..\..\..\..\examples/soc/hdsc;..\..\..\..\examples/std;..\..\..\..\examples\board\am13x_core;..\..\..\..\interface;..\..\..\..\soc\hdsc\hc32;..\..\..\..\soc\hdsc\drivers\include\adc;..\..\..\..\soc\hdsc\drivers\include\adtim;..\..\..\..\soc\hdsc\drivers\include\aes;..\..\..\..\soc\hdsc\drivers\include\clk;..\..\..\..\soc\hdsc\drivers\include\clktrim;..\..\..\..\soc\hdsc\drivers\include\crc;..\..\..\..\soc\hdsc\drivers\include\dac;..\..\..\..\soc\hdsc\drivers\include\dma;..\..\..\..\soc\hdsc\drivers\include\flash;..\..\..\..\soc\hdsc\drivers\include\gpio;..\..\..\..\soc\hdsc\drivers\include\i2c;..\..\..\..\soc\hdsc\drivers\include\lcd;..\..\..\..\soc\hdsc\drivers\include\lpmode;..\..\..\..\soc\hdsc\drivers\include\lptim;..\..\..\..\soc\hdsc\drivers\include\lpuart;..\..\..\..\soc\hdsc\drivers\include\lvd;..\..\..\..\soc\hdsc\drivers\include\opa;..\..\..\..\soc\hdsc\drivers\include\pca;..\..\..\..\soc\hdsc\drivers\include\pcnt;..\..\..\..\soc\hdsc\drivers\include\ram;..\..\..\..\soc\hdsc\drivers\include\rcc;..\..\..\..\soc\hdsc\drivers\include\rtc;..\..\..\..\soc\hdsc\drivers\include\spi;..\..\..\..\soc\hdsc\drivers\include\tim;..\..\..\..\soc\hdsc\drivers\include\trng;..\..\..\..\soc\hdsc\drivers\include\uart;..\..\..\..\soc\hdsc\drivers\include\vc;..\..\..\..\soc\hdsc\drivers\include\wdt;..\user_code;..\infrared_sensor_interpolation\include;..\ir_thremometer_control\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group bsp_common
    ../../../bsp_common/source/: am_bsp_armlib.c am_bsp_delay_timer.c am_bsp_isr_defer_pendsv.c am_bsp_microlib.c am_bsp_system_heap.c
  group arm
    ../../../../arch/arm/source/: am_arm_nvic.c am_arm_nvic_armcc.s am_arm_systick.c
  group drivers
    ../../../../components/drivers/source/digitron_key/: am_zlg72128_std.c zlg72128.c zlg72128_platform.c
    ../../../../components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../../../../components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../../../../components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../../../../components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../../../../components/drivers/source/fm175xx/: am_fm175xx_ant.c
    ../../../../components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../../../../components/drivers/source/led/: am_led_gpio.c am_led_hc595.c
    ../../../../components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../../../../components/drivers/source/temperature/: am_temp_lm75.c
    ../../../../components/drivers/source/miniport/: am_miniport_view_key.c am_miniport_view_key_595.c
    ../../../../components/drivers/source/sensor/: am_sensor_hts221.c
    ../../../../components/drivers/source/nvram/: am_ep24cxx.c
  group libc
    ../../../../components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../../../../components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../../../../components/service/source/: am_adc.c am_buzzer_dev.c am_dac.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_category_input.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_uart.c am_uart_rngbuf.c am_timer.c am_sensor.c
  group util
    ../../../../components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c
  group soc
    ../../../../soc/hdsc/drivers/source/adc/: am_hc32_adc.c
    ../../../../soc/hdsc/drivers/source/adtim/: am_hc32_adtim_cap.c am_hc32_adtim_pwm.c am_hc32_adtim_timing.c
    ../../../../soc/hdsc/drivers/source/adtim/hw/: amhw_hc32_adtim.c
    ../../../../soc/hdsc/drivers/source/aes/: am_hc32_aes.c
    ../../../../soc/hdsc/drivers/source/clk/: am_hc32_clk.c
    ../../../../soc/hdsc/drivers/source/clktrim/: am_hc32_clktrim.c
    ../../../../soc/hdsc/drivers/source/crc/: am_hc32_crc.c
    ../../../../soc/hdsc/drivers/source/dac/: am_hc32_dac.c
    ../../../../soc/hdsc/drivers/source/dma/: am_hc32_dma.c
    ../../../../soc/hdsc/drivers/source/flash/: am_hc32_flash.c
    ../../../../soc/hdsc/drivers/source/gpio/hw/: amhw_hc32_gpio.c
    ../../../../soc/hdsc/drivers/source/gpio/: am_hc32_gpio.c
    ../../../../soc/hdsc/drivers/source/i2c/: am_hc32_i2c.c am_hc32_i2c_slv.c
    ../../../../soc/hdsc/drivers/source/lcd/: am_hc32_lcd.c
    ../../../../soc/hdsc/drivers/source/lptim/: am_hc32_lptim_timing.c
    ../../../../soc/hdsc/drivers/source/lpuart/hw/: amhw_hc32_lpuart.c
    ../../../../soc/hdsc/drivers/source/lpuart/: am_hc32_lpuart.c
    ../../../../soc/hdsc/drivers/source/lvd/: am_hc32_lvd.c
    ../../../../soc/hdsc/drivers/source/pca/: am_hc32_pca.c
    ../../../../soc/hdsc/drivers/source/pcnt/: am_hc32_pcnt.c
    ../../../../soc/hdsc/drivers/source/ram/: am_hc32_ram.c
    ../../../../soc/hdsc/drivers/source/rcc/hw/: amhw_hc32_rcc.c amhw_hc32_rcc_reset.c
    ../../../../soc/hdsc/drivers/source/rtc/: am_hc32_rtc.c
    ../../../../soc/hdsc/drivers/source/spi/: am_hc32_spi_dma.c am_hc32_spi_int.c am_hc32_spi_poll.c
    ../../../../soc/hdsc/drivers/source/tim/: am_hc32_tim_cap.c am_hc32_tim_pwm.c am_hc32_tim_timing.c
    ../../../../soc/hdsc/drivers/source/trng/: am_hc32_trng.c
    ../../../../soc/hdsc/drivers/source/uart/hw/: amhw_hc32_uart.c
    ../../../../soc/hdsc/drivers/source/vc/: am_hc32_vc.c
    ../../../../soc/hdsc/drivers/source/wdt/: am_hc32_wdt.c
    ../../../../soc/hdsc/drivers/source/opa/: am_hc32x3x_opa.c
    ../../../../soc/hdsc/drivers/source/uart/: am_hc32x3x_uart.c
  group startup
    ../startup/: am_hc32l13x_armcc_startup.s
  group user_code
    ../user_code/: main.c
  group user_config
    ../user_config/: am_board.c am_prj_config.c
    ../user_config/am_hwconf_usrcfg/: am_hwconf_buzzer_pwm.c am_hwconf_debug_uart.c am_hwconf_hc32l13x_adc.c am_hwconf_hc32l13x_aes.c am_hwconf_hc32l13x_arm_nvic.c am_hwconf_hc32l13x_clk.c am_hwconf_hc32l13x_crc.c am_hwconf_hc32l13x_dac.c am_hwconf_hc32l13x_dma.c am_hwconf_hc32l13x_gpio.c am_hwconf_hc32l13x_i2c.c am_hwconf_hc32l13x_i2c_slv.c am_hwconf_hc32l13x_lcd.c am_hwconf_hc32l13x_led_gpio.c am_hwconf_hc32l13x_lptim.c am_hwconf_hc32l13x_lpuart.c am_hwconf_hc32l13x_lvd.c am_hwconf_hc32l13x_opa.c am_hwconf_hc32l13x_pca.c am_hwconf_hc32l13x_pcnt.c am_hwconf_hc32l13x_rtc.c am_hwconf_hc32l13x_spi_dma.c am_hwconf_hc32l13x_spi_int.c am_hwconf_hc32l13x_spi_poll.c am_hwconf_hc32l13x_systick.c am_hwconf_hc32l13x_tim_cap.c am_hwconf_hc32l13x_tim_pwm.c am_hwconf_hc32l13x_tim_timing.c am_hwconf_hc32l13x_trng.c am_hwconf_hc32l13x_uart.c am_hwconf_hc32l13x_vc.c am_hwconf_hc32l13x_wdt.c am_hwconf_key_gpio.c am_hwconf_miniport_595.c am_hwconf_miniport_key.c am_hwconf_miniport_led.c am_hwconf_miniport_view.c am_hwconf_miniport_view_key.c am_hwconf_miniport_zlg72128.c am_hwconf_sensor_hts221.c am_hwconf_system_tick_softimer.c am_hwconf_microport_eeprom.c
    ../user_config/am_servconf_usrcfg/: am_servconf_event_input.c am_servconf_nvram.c
  group infrared_sensor_interpolation
    ../infrared_sensor_interpolation/src/: zal_infrared_sensor_interpolation.lib
  group ir_thremometer_control
    ../ir_thremometer_control/src/: am_user_lcd_display.c ir_thremometer.c ir_thremometer_adc.c ir_thremometer_backlight.c ir_thremometer_beep.c ir_thremometer_key.c ir_thremometer_lcd.c ir_thremometer_power.c ir_thremometer_storage.c ir_thremometer_timer.c
target release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L13X.1.0.0
  cpu: as above
  output: template_am116_core +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M0
  c include: ..\..\..\..\3rdparty/CMSIS/Include;..\..\..\..\arch/arm/include;..\..\..\..\components/drivers/include;..\..\..\..\components/libc/armlib_adapter/include;..\..\..\..\components/libc/microlib_adapter/include;..\..\..\..\components/service/include;..\..\..\..\components/util/include;..\user_code;..\user_config;..\user_config/am_hwconf_usrcfg;..\user_config/am_servconf_usrcfg;..\..\..\..\board/bsp_common/include;..\..\..\..\examples/components;..\..\..\..\examples/soc/hdsc;..\..\..\..\examples/std;..\..\..\..\examples\board\am13x_core;..\..\..\..\interface;..\..\..\..\soc\hdsc\hc32;..\..\..\..\soc\hdsc\drivers\include\adc;..\..\..\..\soc\hdsc\drivers\include\adtim;..\..\..\..\soc\hdsc\drivers\include\aes;..\..\..\..\soc\hdsc\drivers\include\clk;..\..\..\..\soc\hdsc\drivers\include\clktrim;..\..\..\..\soc\hdsc\drivers\include\crc;..\..\..\..\soc\hdsc\drivers\include\dac;..\..\..\..\soc\hdsc\drivers\include\dma;..\..\..\..\soc\hdsc\drivers\include\flash;..\..\..\..\soc\hdsc\drivers\include\gpio;..\..\..\..\soc\hdsc\drivers\include\i2c;..\..\..\..\soc\hdsc\drivers\include\lcd;..\..\..\..\soc\hdsc\drivers\include\lpmode;..\..\..\..\soc\hdsc\drivers\include\lptim;..\..\..\..\soc\hdsc\drivers\include\lpuart;..\..\..\..\soc\hdsc\drivers\include\lvd;..\..\..\..\soc\hdsc\drivers\include\opa;..\..\..\..\soc\hdsc\drivers\include\pca;..\..\..\..\soc\hdsc\drivers\include\pcnt;..\..\..\..\soc\hdsc\drivers\include\ram;..\..\..\..\soc\hdsc\drivers\include\rcc;..\..\..\..\soc\hdsc\drivers\include\rtc;..\..\..\..\soc\hdsc\drivers\include\spi;..\..\..\..\soc\hdsc\drivers\include\tim;..\..\..\..\soc\hdsc\drivers\include\trng;..\..\..\..\soc\hdsc\drivers\include\uart;..\..\..\..\soc\hdsc\drivers\include\vc;..\..\..\..\soc\hdsc\drivers\include\wdt
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000

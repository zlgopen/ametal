# Keil uVision project template_am118_core.uvprojx, settings and files
target debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32L196PCTA HDSC
  pack: HDSC.HC32L19X.1.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: example_am118_core +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M0
  c include: ..\..\..\..\3rdparty/CMSIS/Include;..\..\..\..\arch/arm/include;..\..\..\..\components/drivers/include;..\..\..\..\components/libc/armlib_adapter/include;..\..\..\..\components/libc/microlib_adapter/include;..\..\..\..\components/service/include;..\..\..\..\components/util/include;..\user_code;..\user_config;..\user_config/am_hwconf_usrcfg;..\user_config/am_servconf_usrcfg;..\..\..\..\board/bsp_common/include;..\..\..\..\examples/components;..\..\..\..\examples/soc/zlg;..\..\..\..\examples/std;..\..\..\..\examples\board\am118_core;..\..\..\..\interface;..\..\..\..\soc\zlg\zlg118;..\..\..\..\soc/zlg/drivers/include/adc;..\..\..\..\soc/zlg/drivers/include/bkp;..\..\..\..\soc/zlg/drivers/include/clk;..\..\..\..\soc/zlg/drivers/include/cmp;..\..\..\..\soc/zlg/drivers/include/crc;..\..\..\..\soc/zlg/drivers/include/dac;..\..\..\..\soc/zlg/drivers/include/dma;..\..\..\..\soc/zlg/drivers/include/exti;..\..\..\..\soc/zlg/drivers/include/flash;..\..\..\..\soc/zlg/drivers/include/gpio;..\..\..\..\soc/zlg/drivers/include/i2c;..\..\..\..\soc/zlg/drivers/include/pwr;..\..\..\..\soc/zlg/drivers/include/rcc;..\..\..\..\soc/zlg/drivers/include/spi;..\..\..\..\soc/zlg/drivers/include/syscfg;..\..\..\..\soc/zlg/drivers/include/tim;..\..\..\..\soc/zlg/drivers/include/uart;..\..\..\..\soc/zlg/drivers/include/wdt;..\..\..\..\soc\zlg\drivers\include\adtim;..\..\..\..\soc\zlg\drivers\include\aes;..\..\..\..\soc\zlg\drivers\include\clktrim;..\..\..\..\soc\zlg\drivers\include\lvd;..\..\..\..\soc\zlg\drivers\include\opa;..\..\..\..\soc\zlg\drivers\include\pca;..\..\..\..\soc\zlg\drivers\include\pcnt;..\..\..\..\soc\zlg\drivers\include\ram;..\..\..\..\soc\zlg\drivers\include\trng;..\..\..\..\soc\zlg\drivers\include\vc;..\..\..\..\soc\zlg\drivers\include\lptim;..\..\..\..\soc\zlg\drivers\include\lpuart;..\..\..\..\soc\zlg\drivers\include\lpmode;..\..\..\..\soc\zlg\drivers\include\lcd;..\..\..\..\soc\zlg\drivers\include\rtc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group bsp_common
    ../../../bsp_common/source/: am_bsp_armlib.c am_bsp_delay_timer.c am_bsp_isr_defer_pendsv.c am_bsp_microlib.c am_bsp_system_heap.c
  group arm
    ../../../../arch/arm/source/: am_arm_nvic.c am_arm_nvic_armcc.s am_arm_systick.c
  group drivers
    ../../../../components/drivers/source/digitron_key/: am_zlg72128_std.c zlg72128.c zlg72128_platform.c
    ../../../../components/drivers/source/led/: am_led_gpio.c am_led_hc595.c
    ../../../../components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../../../../components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../../../../components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../../../../components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../../../../components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../../../../components/drivers/source/fm175xx/: am_fm175xx_ant.c
    ../../../../components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../../../../components/drivers/source/i2c/: am_i2c_gpio.c
    ../../../../components/drivers/source/miniport/: am_miniport_view_key.c am_miniport_view_key_595.c
    ../../../../components/drivers/source/sensor/: am_sensor_hts221.c
    ../../../../components/drivers/source/spi/: am_spi_gpio.c
    ../../../../components/drivers/source/temperature/: am_temp_lm75.c
    ../../../../components/drivers/source/rtc/: am_ds1302.c am_pcf85063.c am_rx8025sa.c am_rx8025t.c
  group libc
    ../../../../components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../../../../components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../../../../components/service/source/: am_adc.c am_buzzer_dev.c am_dac.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_category_input.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_uart.c am_uart_rngbuf.c am_timer.c am_sensor.c
  group util
    ../../../../components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c
  group soc
    ../../../../soc/zlg/drivers/source/adc/: am_zlg118_adc.c
    ../../../../soc/zlg/drivers/source/adtim/hw/: amhw_zlg118_adtim.c
    ../../../../soc/zlg/drivers/source/adtim/: am_zlg118_adtim_cap.c am_zlg118_adtim_pwm.c am_zlg118_adtim_timing.c
    ../../../../soc/zlg/drivers/source/aes/: am_zlg118_aes.c
    ../../../../soc/zlg/drivers/source/clk/: am_zlg118_clk.c
    ../../../../soc/zlg/drivers/source/clktrim/: am_zlg118_clktrim.c
    ../../../../soc/zlg/drivers/source/crc/: am_zlg118_crc.c
    ../../../../soc/zlg/drivers/source/dac/: am_zlg118_dac.c
    ../../../../soc/zlg/drivers/source/dma/: am_zlg118_dma.c
    ../../../../soc/zlg/drivers/source/flash/: am_zlg118_flash.c
    ../../../../soc/zlg/drivers/source/gpio/: am_zlg118_gpio.c
    ../../../../soc/zlg/drivers/source/gpio/hw/: amhw_zlg118_gpio.c
    ../../../../soc/zlg/drivers/source/i2c/: am_zlg118_i2c.c am_zlg118_i2c_slv.c
    ../../../../soc/zlg/drivers/source/lcd/: am_zlg118_lcd.c
    ../../../../soc/zlg/drivers/source/lptim/: am_zlg118_lptim_timing.c
    ../../../../soc/zlg/drivers/source/lpuart/hw/: amhw_zlg118_lpuart.c
    ../../../../soc/zlg/drivers/source/lpuart/: am_zlg118_lpuart.c
    ../../../../soc/zlg/drivers/source/lvd/: am_zlg118_lvd.c
    ../../../../soc/zlg/drivers/source/opa/: am_zlg118_opa.c
    ../../../../soc/zlg/drivers/source/pca/: am_zlg118_pca.c
    ../../../../soc/zlg/drivers/source/pcnt/: am_zlg118_pcnt.c
    ../../../../soc/zlg/drivers/source/ram/: am_zlg118_ram.c
    ../../../../soc/zlg/drivers/source/rcc/hw/: amhw_zlg118_rcc.c amhw_zlg118_rcc_reset.c
    ../../../../soc/zlg/drivers/source/rtc/: am_zlg118_rtc.c
    ../../../../soc/zlg/drivers/source/spi/: am_zlg118_spi_dma.c am_zlg118_spi_int.c am_zlg118_spi_poll.c
    ../../../../soc/zlg/drivers/source/tim/: am_zlg118_tim_cap.c am_zlg118_tim_pwm.c am_zlg118_tim_timing.c
    ../../../../soc/zlg/drivers/source/trng/: am_zlg118_trng.c
    ../../../../soc/zlg/drivers/source/uart/: am_zlg118_uart.c
    ../../../../soc/zlg/drivers/source/uart/hw/: amhw_zlg118_uart.c
    ../../../../soc/zlg/drivers/source/vc/: am_zlg118_vc.c
    ../../../../soc/zlg/drivers/source/wdt/: am_zlg118_wdt.c
  group startup
    ../startup/: am_zlg118_armcc_startup.s
  group user_code
    ../user_code/: main.c
  group user_config
    ../user_config/: am_prj_config.c am_board.c
    ../user_config/am_servconf_usrcfg/: am_servconf_nvram.c am_servconf_event_input.c
    ../user_config/am_hwconf_usrcfg/: am_hwconf_buzzer_pwm.c am_hwconf_debug_uart.c am_hwconf_key_gpio.c am_hwconf_miniport_595.c am_hwconf_miniport_key.c am_hwconf_miniport_led.c am_hwconf_miniport_view.c am_hwconf_miniport_view_key.c am_hwconf_miniport_zlg72128.c am_hwconf_sensor_hts221.c am_hwconf_system_tick_softimer.c am_hwconf_zlg118_adc.c am_hwconf_zlg118_aes.c am_hwconf_zlg118_arm_nvic.c am_hwconf_zlg118_clk.c am_hwconf_zlg118_crc.c am_hwconf_zlg118_dac.c am_hwconf_zlg118_dma.c am_hwconf_zlg118_gpio.c am_hwconf_zlg118_i2c.c am_hwconf_zlg118_i2c_slv.c am_hwconf_zlg118_lcd.c am_hwconf_zlg118_led_gpio.c am_hwconf_zlg118_lptim.c am_hwconf_zlg118_lpuart.c am_hwconf_zlg118_lvd.c am_hwconf_zlg118_opa.c am_hwconf_zlg118_pcnt.c am_hwconf_zlg118_rtc.c am_hwconf_zlg118_spi_dma.c am_hwconf_zlg118_spi_int.c am_hwconf_zlg118_spi_poll.c am_hwconf_zlg118_systick.c am_hwconf_zlg118_tim_cap.c am_hwconf_zlg118_tim_pwm.c am_hwconf_zlg118_tim_timing.c am_hwconf_zlg118_trng.c am_hwconf_zlg118_uart.c am_hwconf_zlg118_vc.c am_hwconf_zlg118_wdt.c am_hwconf_microport_ds1302.c am_hwconf_microport_rtc.c am_hwconf_microport_rx8025t.c
target release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32L196PCTA HDSC
  pack: HDSC.HC32L19X.1.0.0
  cpu: as above
  output: template_am116_core +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M0
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000

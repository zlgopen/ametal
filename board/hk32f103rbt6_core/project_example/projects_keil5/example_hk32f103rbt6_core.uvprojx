# Keil uVision project example_hk32f103rbt6_core.uvprojx, settings and files
target debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: example_hk32f103rbt6_core +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M3
  c include: ..\user_code;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config\am_servconf_usrcfg;..\..\..\..\3rdparty\CMSIS\Include;..\..\..\..\arch\arm\include;..\..\..\bsp_common\include;..\..\..\..\components\drivers\include;..\..\..\..\components\service\include;..\..\..\..\components\util\include;..\..\..\..\examples\components;..\..\..\..\examples\soc\hk;..\..\..\..\examples\std;..\..\..\..\interface;..\..\..\..\soc\hk\drivers\include\adc;..\..\..\..\soc\hk\drivers\include\bkp;..\..\..\..\soc\hk\drivers\include\bkp\hw;..\..\..\..\soc\hk\drivers\include\clk;..\..\..\..\soc\hk\drivers\include\cmp;..\..\..\..\soc\hk\drivers\include\crc;..\..\..\..\soc\hk\drivers\include\dac;..\..\..\..\soc\hk\drivers\include\dma;..\..\..\..\soc\hk\drivers\include\exti;..\..\..\..\soc\hk\drivers\include\flash\hw;..\..\..\..\soc\hk\drivers\include\gpio;..\..\..\..\soc\hk\drivers\include\i2c;..\..\..\..\soc\hk\drivers\include\pwr;..\..\..\..\soc\hk\drivers\include\rcc;..\..\..\..\soc\hk\drivers\include\spi;..\..\..\..\soc\hk\drivers\include\syscfg\hw;..\..\..\..\soc\hk\drivers\include\tim;..\..\..\..\soc\hk\drivers\include\uart;..\..\..\..\soc\hk\drivers\include\wdt;..\..\..\bsp_common\include;..\user_config;..\..\..\..\soc\hk\drivers\include\gpio\hw;..\..\..\..\soc\hk\drivers\include\pwr\hw;..\..\..\..\soc\hk\drivers\include\rtc\hw;..\..\..\..\soc\hk\drivers\include\afio\hw;..\..\..\..\soc\hk\drivers\include\rcc\hw;..\..\..\..\soc\hk\drivers\include\exti\hw;..\..\..\..\soc\hk\drivers\include\adc;..\..\..\..\soc\hk\drivers\include\adc\hw;..\..\..\..\soc\hk\drivers\include\flash;..\..\..\..\soc\hk\drivers\include\crc\hw;..\..\..\..\soc\hk\drivers\include\dac\hw;..\..\..\..\soc\hk\drivers\include\dma\hw;..\..\..\..\soc\hk\drivers\include\i2c\hw;..\..\..\..\soc\hk\drivers\include\wdt\hw;..\..\..\..\soc\hk\drivers\include\spi\hw;..\..\..\..\soc\hk\drivers\include\tim\hw;..\..\..\..\arch\arm\include\hw;..\..\..\..\soc\hk\drivers\include\rtc;..\..\..\..\examples\components;..\..\..\..\components\libc\newlib_adapter\include;..\..\..\..\soc\hk\drivers\include\ili9341;..\..\..\..\components\libc\armlib_adapter\include;..\..\..\..\components\libc\microlib_adapter\include;..\..\..\..\components\libc\newlib_adapter\include;..\..\..\..\soc\hk\drivers\include\can;..\..\..\..\soc\hk\drivers\include\can\hw;..\..\..\..\soc\hk\drivers\include\usbd;..\..\..\..\soc\hk\drivers\include\usbd\hw;..\..\..\..\components\usb\device;..\..\..\..\components\usb\include;..\..\..\..\components\usb\osa;..\..\..\..\components\usb\host\config;..\..\..\..\components\usb\host\common\include;..\..\..\..\components\usb\host\class\include;..\..\..\..\components\usb\device\config\include;..\..\..\..\components\usb\host;..\..\..\..\soc\hk\drivers\include\syscfg;..\..\..\..\components\drivers\source\lcd;..\..\..\..\examples\std;..\..\..\..\examples\soc\hk;..\..\..\..\examples\components;..\..\..\..\soc\hk\hk32f103rbt6;..\..\..\..\examples\board\hk32f103rbt6_core;..\..\..\..\soc\hk\drivers\include\flash;..\..\..\..\soc\hk\drivers\include\uart\hw;..\..\..\..\soc\hk\drivers\include\rcc\hw;..\..\..\..\soc\hk\drivers\include\bootloader
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group bsp_common
    ../../../bsp_common/source/: am_bsp_armlib.c am_bsp_microlib.c am_bsp_delay_timer.c am_bsp_system_heap.c am_bsp_isr_defer_pendsv.c
  group arm
    ../../../../arch/arm/source/: am_arm_nvic.c am_arm_nvic_armcc.s am_arm_systick.c
  group drivers
    ../../../../components/drivers/source/adc/: am_cs1237.c
    ../../../../components/drivers/source/ble/: am_zlg9021.c
    ../../../../components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../../../../components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../../../../components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../../../../components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../../../../components/drivers/source/digitron_key/: am_zlg72128_std.c zlg72128.c zlg72128_platform.c
    ../../../../components/drivers/source/fingerprint/: am_ts10x.c
    ../../../../components/drivers/source/flash/: am_mx25xx.c
    ../../../../components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../../../../components/drivers/source/i2c/: am_i2c_gpio.c
    ../../../../components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../../../../components/drivers/source/led/: am_led_gpio.c am_led_hc595.c
    ../../../../components/drivers/source/miniport/: am_miniport_view_key.c am_miniport_view_key_595.c
    ../../../../components/drivers/source/nvram/: am_ep24cxx.c
    ../../../../components/drivers/source/rtc/: am_ds1302.c am_pcf85063.c am_rx8025sa.c am_rx8025t.c
    ../../../../components/drivers/source/sht20/: am_sht20.c
    ../../../../components/drivers/source/spi/: am_spi_gpio.c
    ../../../../components/drivers/source/temperature/: am_temp_lm75.c
    ../../../../components/drivers/source/uart/: am_sc16is7xx.c
    ../../../../components/drivers/source/zigbee/: am_zm516x.c
    ../../../../components/drivers/source/zlg600/: am_zlg600.c
    ../../../../components/drivers/source/lcd/: am_ili9341.c am_ili9341_intfc_3wire.c
    ../../../../components/drivers/source/fm175xx/: am_fm175xx_zlg217.lib am_fm175xx_ant.c
    ../../../../components/drivers/source/sensor/: am_sensor_bh1730fvc.c am_sensor_bma253.c am_sensor_bme280.c am_sensor_bmg160.c am_sensor_bmp280.c am_sensor_hts221.c am_sensor_lis3mdl.c am_sensor_lps22hb.c am_sensor_lsm6dsl.c am_sensor_mmc5883ma.c am_sensor_shtc1.c
    ../../../../components/drivers/source/thermocouple/: am_thermocouple.c
    ../../../../components/drivers/source/zsn603/: zsn603.c zsn603_platform.c
  group libc
    ../../../../components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../../../../components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../../../../components/service/source/: am_adc.c am_buzzer_dev.c am_event_category_input.c am_dac.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_timer.c am_uart.c am_uart_rngbuf.c am_crc_soft.c am_crc_table_def.c am_sdio.c am_sensor.c am_xmodem.c
  group util
    ../../../../components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c
  group soc
    ../../../../soc/hk/drivers/source/clk/: am_hk32f103rbt6_clk.c
    ../../../../soc/hk/drivers/source/crc/: am_hk32f103rbt6_crc.c
    ../../../../soc/hk/drivers/source/dma/: am_hk32f103rbt6_dma.c
    ../../../../soc/hk/drivers/source/flash/: am_hk32f103rbt6_flash.c
    ../../../../soc/hk/drivers/source/gpio/: am_hk32f103rbt6_gpio.c
    ../../../../soc/hk/drivers/source/rcc/hw/: amhw_hk32f103rbt6_rcc.c
    ../../../../soc/hk/drivers/source/rtc/: am_hk32f103rbt6_rtc.c
    ../../../../soc/hk/drivers/source/adc/: am_hk32f103rbt6_adc.c
    ../../../../soc/hk/drivers/source/can/: am_hk32f103rbt6_can.c
    ../../../../soc/hk/drivers/source/can/hw/: amhw_hk32f103rbt6_can.c
    ../../../../soc/hk/drivers/source/i2c/: am_hk32f103rbt6_i2c.c am_hk32f103rbt6_i2c_slv.c
    ../../../../soc/hk/drivers/source/pwr/: am_hk32f103rbt6_pwr.c
    ../../../../soc/hk/drivers/source/spi/: am_hk32f103rbt6_spi_dma.c am_hk32f103rbt6_spi_int.c am_hk32f103rbt6_spi_poll.c am_hk32f103rbt6_spi_slv_dma.c
    ../../../../soc/hk/drivers/source/tim/: am_hk32f103rbt6_tim_cap.c am_hk32f103rbt6_tim_pwm.c am_hk32f103rbt6_tim_timing.c
    ../../../../soc/hk/drivers/source/uart/: am_hk32f103rbt6_usart.c
    ../../../../soc/hk/drivers/source/uart/hw/: amhw_hk32f103rbt6_usart.c
    ../../../../soc/hk/drivers/source/wdt/: am_hk32f103rbt6_iwdg.c am_hk32f103rbt6_wwdg.c
  group examples_board
    ../../../../examples/board/hk32f103rbt6_core/adc/: demo_hk32f103rbt6_core_hw_adc_dma.c demo_hk32f103rbt6_core_hw_adc_int.c demo_hk32f103rbt6_core_std_adc.c demo_hk32f103rbt6_core_std_multichan_adc.c
    ../../../../examples/board/hk32f103rbt6_core/buzzer/: demo_hk32f103rbt6_core_std_buzzer.c
    ../../../../examples/board/hk32f103rbt6_core/clk/: demo_hk32f103rbt6_core_hw_clk.c
    ../../../../examples/board/hk32f103rbt6_core/crc/: demo_hk32f103rbt6_core_std_crc.c
    ../../../../examples/board/hk32f103rbt6_core/delay/: demo_hk32f103rbt6_core_std_delay.c
    ../../../../examples/board/hk32f103rbt6_core/dma/: demo_hk32f103rbt6_core_drv_dma_m2m.c
    ../../../../examples/board/hk32f103rbt6_core/flash/: demo_hk32f103rbt6_core_drv_flash.c
    ../../../../examples/board/hk32f103rbt6_core/gpio/: demo_hk32f103rbt6_core_hw_gpio.c demo_hk32f103rbt6_core_hw_gpio_trigger.c demo_hk32f103rbt6_core_std_gpio.c demo_hk32f103rbt6_core_std_gpio_trigger.c
    ../../../../examples/board/hk32f103rbt6_core/input_event/: demo_hk32f103rbt6_core_std_key_input_event.c
    ../../../../examples/board/hk32f103rbt6_core/iwdg/: demo_hk32f103rbt6_core_hw_iwdg.c demo_hk32f103rbt6_core_std_iwdg.c
    ../../../../examples/board/hk32f103rbt6_core/led/: demo_hk32f103rbt6_core_std_led.c
    ../../../../examples/board/hk32f103rbt6_core/rtc/: demo_hk32f103rbt6_core_std_rtc.c
    ../../../../examples/board/hk32f103rbt6_core/timer/: demo_hk32f103rbt6_core_hw_tim_cap.c demo_hk32f103rbt6_core_hw_tim_cmp_toggle.c demo_hk32f103rbt6_core_hw_tim_pwm.c demo_hk32f103rbt6_core_hw_tim_timing.c demo_hk32f103rbt6_core_std_tim1_cap.c demo_hk32f103rbt6_core_std_tim1_pwm.c demo_hk32f103rbt6_core_std_tim1_timing.c demo_hk32f103rbt6_core_std_tim2_cap.c demo_hk32f103rbt6_core_std_tim2_pwm.c demo_hk32f103rbt6_core_std_tim2_timing.c demo_hk32f103rbt6_core_std_tim3_cap.c demo_hk32f103rbt6_core_std_tim3_pwm.c demo_hk32f103rbt6_core_std_tim3_timing.c demo_hk32f103rbt6_core_std_tim4_cap.c demo_hk32f103rbt6_core_std_tim4_pwm.c demo_hk32f103rbt6_core_std_tim4_timing.c
    ../../../../examples/board/hk32f103rbt6_core/usart/: demo_hk32f103rbt6_core_hw_usart_int.c demo_hk32f103rbt6_core_hw_usart_polling.c demo_hk32f103rbt6_core_hw_usart_rx_dma.c demo_hk32f103rbt6_core_hw_usart_tx_dma.c demo_hk32f103rbt6_core_std_usart_polling.c demo_hk32f103rbt6_core_std_usart_ringbuf.c
    ../../../../examples/board/hk32f103rbt6_core/wwdg/: demo_hk32f103rbt6_core_hw_wwdg.c demo_hk32f103rbt6_core_std_wwdg.c
    ../../../../examples/board/hk32f103rbt6_core/microport_board/: demo_hk32f103rbt6_core_microport_ds1302.c demo_hk32f103rbt6_core_microport_eeprom.c demo_hk32f103rbt6_core_microport_eeprom_nvram.c demo_hk32f103rbt6_core_microport_flash.c demo_hk32f103rbt6_core_microport_flash_ftl.c demo_hk32f103rbt6_core_microport_flash_mtd.c demo_hk32f103rbt6_core_microport_rs485.c demo_hk32f103rbt6_core_microport_rtc.c demo_hk32f103rbt6_core_microport_rx8025t.c
    ../../../../examples/board/hk32f103rbt6_core/miniport_board/: demo_hk32f103rbt6_core_miniport_digitron.c demo_hk32f103rbt6_core_miniport_hc595_digitron.c demo_hk32f103rbt6_core_miniport_hc595_digitron_key.c demo_hk32f103rbt6_core_miniport_hc595_digitron_temp.c demo_hk32f103rbt6_core_miniport_hc595_led.c demo_hk32f103rbt6_core_miniport_key.c demo_hk32f103rbt6_core_miniport_key_digitron.c demo_hk32f103rbt6_core_miniport_led.c demo_hk32f103rbt6_core_miniport_zlg72128.c
  group examples_components
    ../../../../examples/components/drivers/: demo_ep24cxx.c demo_mx25xx.c demo_fm175xx_cpu_card.c demo_fm175xx_picca_halt.c demo_fm175xx_picca_lpcd_read_id.c demo_fm175xx_picca_read_block.c demo_fm175xx_picca_read_id.c demo_fm175xx_picca_val_operate.c demo_fm175xx_picca_write_block.c demo_fm175xx_piccb_read_id.c
    ../../../../examples/components/service/: demo_ftl.c demo_mtd.c
  group examples_soc
    ../../../../examples/soc/hk/dma/: demo_hk32f103rbt6_drv_dma_m2m.c
    ../../../../examples/soc/hk/gpio/: demo_hk32f103rbt6_hw_gpio_trigger.c demo_hk32f103rbt6_hw_gpio.c
    ../../../../examples/soc/hk/timer/: demo_hk32f103rbt6_hw_tim_cap.c demo_hk32f103rbt6_hw_tim_cmp_toggle.c demo_hk32f103rbt6_hw_tim_pwm.c demo_hk32f103rbt6_hw_tim_pwm_dead.c demo_hk32f103rbt6_hw_tim_timing.c
    ../../../../examples/soc/hk/wdg/: demo_hk32f103rbt6_hw_iwdg.c demo_hk32f103rbt6_hw_wwdg.c
    ../../../../examples/soc/hk/clk/: demo_hk32f103rbt6_hw_clk.c
    ../../../../examples/soc/hk/uart/: demo_hk32f103rbt6_hw_usart_int.c demo_hk32f103rbt6_hw_usart_polling.c demo_hk32f103rbt6_hw_usart_rx_dma.c demo_hk32f103rbt6_hw_usart_tx_dma.c
    ../../../../examples/soc/hk/flash/: demo_hk32f103rbt6_drv_flash.c
    ../../../../examples/soc/hk/adc/: demo_hk32f103rbt6_hw_adc_dma.c demo_hk32f103rbt6_hw_adc_int.c
    ../../../../examples/soc/hk/can/: demo_hk32f103rbt6_can.c
  group examples_std
    ../../../../examples/std/adc/: demo_std_adc.c demo_std_adc_ntc.c demo_std_multichan_adc.c
    ../../../../examples/std/buzzer/: demo_std_buzzer.c
    ../../../../examples/std/cap/: demo_std_timer_cap.c
    ../../../../examples/std/crc/: demo_std_crc.c
    ../../../../examples/std/delay/: demo_std_delay.c
    ../../../../examples/std/digitron/: demo_std_digitron_60s_counting.c demo_std_digitron_temp.c
    ../../../../examples/std/gpio/: demo_std_gpio.c demo_std_gpio_trigger.c
    ../../../../examples/std/hc595/: demo_std_hc595_led.c
    ../../../../examples/std/i2c/: demo_std_i2c_lm75.c demo_std_i2c_master_async.c demo_std_i2c_master_sync.c demo_std_i2c_slave.c demo_std_i2c_slave_subaddr.c
    ../../../../examples/std/input/: demo_std_4key.c demo_std_key.c demo_std_key_digitron.c demo_std_key_digitron_rngbuf.c
    ../../../../examples/std/led/: demo_std_led.c demo_std_led_water_light.c
    ../../../../examples/std/nvram/: demo_std_nvram.c
    ../../../../examples/std/pwm/: demo_std_timer_pwm.c
    ../../../../examples/std/rtc/: demo_std_rtc.c
    ../../../../examples/std/softimer/: demo_std_softimer.c
    ../../../../examples/std/spi/: demo_std_spi_flash.c demo_std_spi_master.c demo_std_spi_slave.c
    ../../../../examples/std/timer/: demo_std_timer_timing.c
    ../../../../examples/std/uart/: demo_std_uart_polling.c demo_std_uart_ringbuf.c demo_std_uart_rs485.c
    ../../../../examples/std/wdt/: demo_std_wdt.c
  group startup
    ../startup/: am_hk32f103rbt6_armcc_startup.s
  group user_code
    ../user_code/: main.c
  group user_config
    ../user_config/am_hwconf_usrcfg/: am_hwconf_arm_nvic.c am_hwconf_buzzer_pwm.c am_hwconf_debug_uart.c am_hwconf_key_gpio.c am_hwconf_led_gpio.c am_hwconf_system_tick_softimer.c am_hwconf_hk32f103rbt6_clk.c am_hwconf_hk32f103rbt6_crc.c am_hwconf_hk32f103rbt6_dma.c am_hwconf_hk32f103rbt6_gpio.c am_hwconf_hk32f103rbt6_iwdg.c am_hwconf_hk32f103rbt6_rtc.c am_hwconf_hk32f103rbt6_systick.c am_hwconf_hk32f103rbt6_tim_cap.c am_hwconf_hk32f103rbt6_tim_pwm.c am_hwconf_hk32f103rbt6_tim_timing.c am_hwconf_hk32f103rbt6_usart.c am_hwconf_hk32f103rbt6_wwdg.c am_hwconf_hk32f103rbt6_adc.c am_hwconf_fm175xx.c am_hwconf_lm75.c am_hwconf_microport_ds1302.c am_hwconf_microport_eeprom.c am_hwconf_microport_flash.c am_hwconf_microport_rs485.c am_hwconf_microport_rtc.c am_hwconf_microport_rx8025t.c am_hwconf_miniport_595.c am_hwconf_miniport_key.c am_hwconf_miniport_led.c am_hwconf_miniport_view.c am_hwconf_miniport_view_key.c am_hwconf_miniport_zlg72128.c am_hwconf_sensor_hts221.c am_hwconf_hk32f103rbt6_i2c.c am_hwconf_hk32f103rbt6_i2c_slv.c am_hwconf_hk32f103rbt6_pwr.c am_hwconf_hk32f103rbt6_spi_dma.c am_hwconf_hk32f103rbt6_spi_int.c am_hwconf_hk32f103rbt6_spi_poll.c am_hwconf_hk32f103rbt6_spi_slv_dma.c
    ../user_config/am_servconf_usrcfg/: am_servconf_event_input.c am_servconf_nvram.c
    ../user_config/: am_board.c am_prj_config.c

# Keil uVision project example_amks16rfid8.uvprojx, settings and files
target debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKL16Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.14.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: example_amks16rfid8 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG,AM_CORTEX_M0,KL16,CRP_ENABLE
  c include: .\user_code;.\user_config\am_hwconf_usrcfg;.\user_config\am_servconf_usrcfg;.\user_config;..\..\..\..\3rdparty\CMSIS\Include;..\..\..\..\arch\arm\include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\armlib_adapter\include;..\..\..\..\components\libc\microlib_adapter\include;..\..\..\..\components\service\include;..\..\..\..\components\util\include;..\..\..\..\interface;..\..\..\..\soc\freescale\drivers\include\adc;..\..\..\..\soc\freescale\drivers\include\bme;..\..\..\..\soc\freescale\drivers\include\clk;..\..\..\..\soc\freescale\drivers\include\cmp;..\..\..\..\soc\freescale\drivers\include\dac;..\..\..\..\soc\freescale\drivers\include\dma;..\..\..\..\soc\freescale\drivers\include\ftfa;..\..\..\..\soc\freescale\drivers\include\gpio;..\..\..\..\soc\freescale\drivers\include\i2c;..\..\..\..\soc\freescale\drivers\include\i2s;..\..\..\..\soc\freescale\drivers\include\llwu;..\..\..\..\soc\freescale\drivers\include\lptmr;..\..\..\..\soc\freescale\drivers\include\mcg;..\..\..\..\soc\freescale\drivers\include\mcm;..\..\..\..\soc\freescale\drivers\include\pinctr;..\..\..\..\soc\freescale\drivers\include\pit;..\..\..\..\soc\freescale\drivers\include\pmc;..\..\..\..\soc\freescale\drivers\include\pmu;..\..\..\..\soc\freescale\drivers\include\rcm;..\..\..\..\soc\freescale\drivers\include\rtc;..\..\..\..\soc\freescale\drivers\include\sim;..\..\..\..\soc\freescale\drivers\include\smc;..\..\..\..\soc\freescale\drivers\include\spi;..\..\..\..\soc\freescale\drivers\include\tpm;..\..\..\..\soc\freescale\drivers\include\tsi;..\..\..\..\soc\freescale\drivers\include\uart;..\..\..\..\soc\freescale\drivers\include\wdt;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config\am_servconf_usrcfg;..\..\..\bsp_common\include;..\..\..\..\examples\board;..\..\..\..\examples\components;..\..\..\..\examples\soc\freescale;..\..\..\..\examples\std;..\..\..\..\examples\board\amks16z_core;..\..\..\..\soc\freescale\kl26;..\..\..\..\examples\board\amks16rfid;..\..\..\..\examples\board\amks16rfid-8;..\user_config\am_encrypt\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: .\example_amks16rfid8.sct
  link misc: --remove
  group bsp_common
    ../../../bsp_common/source/: am_bsp_armlib.c am_bsp_delay_timer.c am_bsp_isr_defer_pendsv.c am_bsp_microlib.c am_bsp_system_heap.c
  group arm
    ../../../../arch/arm/source/: am_arm_nvic.c am_arm_nvic_armcc.s am_arm_systick.c
  group drivers
    ../../../../components/drivers/source/adc/: am_cs1237.c
    ../../../../components/drivers/source/ble/: am_zlg9021.c
    ../../../../components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../../../../components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../../../../components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../../../../components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../../../../components/drivers/source/digitron_key/: am_zlg72128_std.c zlg72128.c zlg72128_platform.c
    ../../../../components/drivers/source/fingerprint/: am_ts10x.c
    ../../../../components/drivers/source/flash/: am_mx25xx.c
    ../../../../components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../../../../components/drivers/source/i2c/: am_i2c_gpio.c
    ../../../../components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../../../../components/drivers/source/led/: am_led_gpio.c am_led_hc595.c
    ../../../../components/drivers/source/miniport/: am_miniport_view_key.c am_miniport_view_key_595.c
    ../../../../components/drivers/source/nvram/: am_ep24cxx.c
    ../../../../components/drivers/source/rtc/: am_ds1302.c am_pcf85063.c am_rx8025sa.c am_rx8025t.c
    ../../../../components/drivers/source/sht20/: am_sht20.c
    ../../../../components/drivers/source/spi/: am_spi_gpio.c
    ../../../../components/drivers/source/temperature/: am_temp_lm75.c
    ../../../../components/drivers/source/uart/: am_sc16is7xx.c
    ../../../../components/drivers/source/zigbee/: am_zm516x.c
    ../../../../components/drivers/source/zlg600/: am_zlg600.c
    ../../../../components/drivers/source/fm175xx/: am_fm175xx_kl16.lib am_fm175xx_uartcmd_k116.lib am_fm175xx_ant.c
  group libc
    ../../../../components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../../../../components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../../../../components/service/source/: am_adc.c am_buzzer_dev.c am_dac.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_category_input.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_timer.c am_uart.c am_uart_rngbuf.c
  group util
    ../../../../components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c am_encrypt.lib
  group soc
    ../../../../soc/freescale/drivers/source/adc/hw/: amhw_fsl_adc.c
    ../../../../soc/freescale/drivers/source/adc/: am_fsl_adc.c am_kl26_adc_dma.c
    ../../../../soc/freescale/drivers/source/clk/: am_kl26_clk.c
    ../../../../soc/freescale/drivers/source/dac/hw/: amhw_fsl_dac.c
    ../../../../soc/freescale/drivers/source/dac/: am_fsl_dac.c
    ../../../../soc/freescale/drivers/source/dma/: am_kl26_dma.c
    ../../../../soc/freescale/drivers/source/ftfa/: am_fsl_ftfa.c
    ../../../../soc/freescale/drivers/source/ftfa/hw/: amhw_fsl_ftfa.c
    ../../../../soc/freescale/drivers/source/gpio/: am_kl26_gpio.c
    ../../../../soc/freescale/drivers/source/i2c/: am_fsl_i2c.c
    ../../../../soc/freescale/drivers/source/i2s/hw/: amhw_fsl_i2s.c
    ../../../../soc/freescale/drivers/source/lptmr/: am_fsl_lptmr_timing.c
    ../../../../soc/freescale/drivers/source/pit/: am_fsl_pit_timing.c
    ../../../../soc/freescale/drivers/source/pmu/: am_kl26_pmu.c
    ../../../../soc/freescale/drivers/source/rtc/: am_fsl_rtc.c
    ../../../../soc/freescale/drivers/source/spi/: am_kl26_spi_dma.c am_kl26_spi_int.c am_kl26_spi_poll.c
    ../../../../soc/freescale/drivers/source/spi/hw/: amhw_fsl_spi.c
    ../../../../soc/freescale/drivers/source/tpm/: am_fsl_tpm_cap.c am_fsl_tpm_timing.c am_fsl_tpm_pwm.c
    ../../../../soc/freescale/drivers/source/tsi/: am_fsl_tsi.c
    ../../../../soc/freescale/drivers/source/uart/hw/: amhw_fsl_uart.c
    ../../../../soc/freescale/drivers/source/uart/: am_fsl_uart.c
    ../../../../soc/freescale/drivers/source/wdt/: am_kl26_wdt.c
  group examples_board
    ../../../../examples/board/amks16z_core/adc/: demo_amks16z_core_hw_adc_int.c demo_amks16z_core_hw_adc_poll.c demo_amks16z_core_std_adc_descs_st.c demo_amks16z_core_std_adc_dif_st.c demo_amks16z_core_std_adc_st.c
    ../../../../examples/board/amks16z_core/bme/: demo_amks16z_core_hw_bme_deco_loads.c demo_amks16z_core_hw_bme_deco_stores.c demo_amks16z_core_hw_bme_deco_stores_gpio.c
    ../../../../examples/board/amks16z_core/buzzer/: demo_amks16z_core_std_buzzer.c
    ../../../../examples/board/amks16z_core/cmp/: demo_amks16z_core_hw_cmp_int.c
    ../../../../examples/board/amks16z_core/dac/: demo_amks16z_core_hw_dac.c demo_amks16z_core_hw_dac_buf_int.c demo_amks16z_core_hw_dac_dma_st.c demo_amks16z_core_std_dac.c
    ../../../../examples/board/amks16z_core/dma/: demo_amks16z_core_dr_dma_m2m.c
    ../../../../examples/board/amks16z_core/ftfa/: demo_amks16z_core_dr_ftfa.c demo_amks16z_core_hw_ftfa.c
    ../../../../examples/board/amks16z_core/gpio/: demo_amks16z_core_hw_fgpio.c demo_amks16z_core_hw_gpio.c demo_amks16z_core_hw_gpio_int.c demo_amks16z_core_std_gpio.c demo_amks16z_core_std_gpio_trigger.c
    ../../../../examples/board/amks16z_core/i2c/: demo_amks16z_core_hw_i2c_master_poll.c demo_amks16z_core_std_i2c_lm75.c
    ../../../../examples/board/amks16z_core/i2s/: demo_amks16z_core_hw_i2s_dma.c demo_amks16z_core_hw_i2s_int.c demo_amks16z_core_hw_i2s_polling.c
    ../../../../examples/board/amks16z_core/led/: demo_amks16z_core_std_led.c
    ../../../../examples/board/amks16z_core/lptmr/: demo_amks16z_core_hw_lptmr_timing.c demo_amks16z_core_std_lptmr_timing.c
    ../../../../examples/board/amks16z_core/microport_board/: demo_amks16z_core_microport_ds1302.c demo_amks16z_core_microport_eeprom.c demo_amks16z_core_microport_eeprom_nvram.c demo_amks16z_core_microport_flash.c demo_amks16z_core_microport_flash_ftl.c demo_amks16z_core_microport_flash_mtd.c demo_amks16z_core_microport_rs485.c demo_amks16z_core_microport_rtc.c demo_amks16z_core_microport_rx8025t.c demo_amks16z_core_microport_usb.c
    ../../../../examples/board/amks16z_core/miniport_board/: demo_amks16z_core_miniport_digitron.c demo_amks16z_core_miniport_hc595_digitron.c demo_amks16z_core_miniport_hc595_digitron_key.c demo_amks16z_core_miniport_hc595_digitron_temp.c demo_amks16z_core_miniport_hc595_led.c demo_amks16z_core_miniport_key.c demo_amks16z_core_miniport_key_digitron.c demo_amks16z_core_miniport_led.c demo_amks16z_core_miniport_zlg72128.c
    ../../../../examples/board/amks16z_core/pit/: demo_amks16z_core_hw_pit_1_32bit_timing.c demo_amks16z_core_std_pit_1_32bit_timing.c demo_amks16z_core_std_pit_2_64bit_timing.c
    ../../../../examples/board/amks16z_core/pmu/: demo_amks16z_core_std_pmu_lowpower.c
    ../../../../examples/board/amks16z_core/rtc/: demo_amks16z_core_hw_rtc_sec_int.c demo_amks16z_core_std_rtc.c
    ../../../../examples/board/amks16z_core/sec/: demo_amks16z_core_hw_backdoor_sec.c
    ../../../../examples/board/amks16z_core/sim_uid/: demo_amks16z_core_hw_sim_uid.c
    ../../../../examples/board/amks16z_core/spi/: demo_amks16z_core_hw_spi_master.c demo_amks16z_core_hw_spi_slave.c demo_amks16z_core_hw_spi_slave_irq.c demo_amks16z_core_hw_spi_slave_match.c demo_amks16z_core_std_spi_flash_dma.c demo_amks16z_core_std_spi_flash_int.c demo_amks16z_core_std_spi_master_dma.c demo_amks16z_core_std_spi_master_int.c
    ../../../../examples/board/amks16z_core/tpm/: demo_amks16z_core_hw_tpm_cap.c demo_amks16z_core_hw_tpm_pwm.c demo_amks16z_core_hw_tpm_timing.c demo_amks16z_core_std_tpm_cap.c demo_amks16z_core_std_tpm_pwm.c demo_amks16z_core_std_tpm_timing.c
    ../../../../examples/board/amks16z_core/tsi/: demo_amks16z_core_dr_tsi_int.c demo_amks16z_core_hw_tsi.c demo_amks16z_core_hw_tsi_int.c
    ../../../../examples/board/amks16z_core/uart/: demo_amks16z_core_hw_uart_int.c demo_amks16z_core_hw_uart_polling.c demo_amks16z_core_hw_uart_rx_dma.c demo_amks16z_core_hw_uart_tx_dma.c demo_amks16z_core_std_uart_polling.c demo_amks16z_core_std_uart_ringbuf.c
    ../../../../examples/board/amks16z_core/wdt/: demo_amks16z_core_std_wdt.c demo_amks16z_core_hw_wdt.c
    ../../../../examples/board/amks16rfid/fm175xx/: demo_amks16rfid_fm175xx_lpcd_read_id.c demo_amks16rfid_fm175xx_picca_halt.c demo_amks16rfid_fm175xx_picca_read_block.c demo_amks16rfid_fm175xx_picca_read_id.c demo_amks16rfid_fm175xx_picca_val_operate.c demo_amks16rfid_fm175xx_picca_write_block.c demo_amks16rfid_fm175xx_piccb_read_id.c
    ../../../../examples/board/amks16rfid-8/fm175xx/: demo_amks16rfid8_fm175xx_cpu_card.c demo_amks16rfid8_fm175xx_lpcd_read_id.c demo_amks16rfid8_fm175xx_picca_8ante_read_id.c demo_amks16rfid8_fm175xx_picca_halt.c demo_amks16rfid8_fm175xx_picca_read_block.c demo_amks16rfid8_fm175xx_picca_read_id.c demo_amks16rfid8_fm175xx_picca_val_operate.c demo_amks16rfid8_fm175xx_picca_write_block.c demo_amks16rfid8_fm175xx_lpcd_vlps.c
    ../../../../examples/board/amks16rfid-8/uart_cmd_read_card/: demo_amks16rfid8_uartcmd_handle.c demo_amks16rfid8_uartcmd_picca_8ante_read_id.c demo_amks16rfid8_uartcmd_picca_auto_detect.c demo_amks16rfid8_uartcmd_ultralight_write_block.c
  group examples_components
    ../../../../examples/components/drivers/: demo_ep24cxx.c demo_mx25xx.c demo_fm175xx_cpu_card.c demo_fm175xx_picca_halt.c demo_fm175xx_picca_lpcd_read_id.c demo_fm175xx_picca_read_block.c demo_fm175xx_picca_read_id.c demo_fm175xx_picca_val_operate.c demo_fm175xx_picca_write_block.c demo_fm175xx_piccb_read_id.c
    ../../../../examples/components/service/: demo_ftl.c demo_mtd.c
  group examples_soc
    ../../../../examples/soc/freescale/adc/: demo_fsl_hw_adc_int.c demo_fsl_hw_adc_poll.c demo_fsl_std_adc_descs_st.c demo_fsl_std_adc_dif_st.c
    ../../../../examples/soc/freescale/bme/: demo_kl26_hw_bme_deco_loads.c demo_kl26_hw_bme_deco_stores.c demo_kl26_hw_bme_deco_stores_gpio.c
    ../../../../examples/soc/freescale/cmp/: demo_fsl_hw_cmp_int.c
    ../../../../examples/soc/freescale/dac/: demo_fsl_hw_dac.c demo_fsl_hw_dac_buf_int.c demo_fsl_std_dac.c demo_kl26_hw_dac_dma_st.c
    ../../../../examples/soc/freescale/dma/: demo_kl26_dr_dma_m2m.c
    ../../../../examples/soc/freescale/ftfa/: demo_fsl_dr_ftfa.c demo_fsl_hw_ftfa.c
    ../../../../examples/soc/freescale/gpio/: demo_kl26_hw_fgpio.c demo_kl26_hw_gpio.c demo_kl26_hw_gpio_int.c
    ../../../../examples/soc/freescale/i2c/: demo_fsl_hw_i2c_master_poll.c
    ../../../../examples/soc/freescale/i2s/: demo_fsl_hw_i2s_int.c demo_fsl_hw_i2s_polling.c demo_kl26_hw_i2s_dma.c
    ../../../../examples/soc/freescale/lptmr/: demo_kl26_hw_lptmr_timing.c
    ../../../../examples/soc/freescale/pit/: demo_kl26_hw_pit_1_32bit_timing.c
    ../../../../examples/soc/freescale/pmu/: demo_kl26_std_pmu_lowpower.c
    ../../../../examples/soc/freescale/rtc/: demo_fsl_hw_rtc_sec_int.c
    ../../../../examples/soc/freescale/sec/: demo_fsl_hw_backdoor_sec.c
    ../../../../examples/soc/freescale/sim_uid/: demo_kl26_hw_sim_uid.c
    ../../../../examples/soc/freescale/spi/: demo_fsl_hw_spi_master.c demo_fsl_hw_spi_slave.c demo_fsl_hw_spi_slave_irq.c demo_fsl_hw_spi_slave_match.c
    ../../../../examples/soc/freescale/tpm/: demo_fsl_hw_tpm_cap.c demo_fsl_hw_tpm_pwm.c demo_fsl_hw_tpm_timing.c
    ../../../../examples/soc/freescale/tsi/: demo_fsl_dr_tsi_int.c demo_fsl_hw_tsi.c demo_fsl_hw_tsi_int.c
    ../../../../examples/soc/freescale/uart/: demo_fsl_hw_uart_int.c demo_fsl_hw_uart_polling.c demo_kl26_hw_uart_rx_dma.c demo_kl26_hw_uart_tx_dma.c
    ../../../../examples/soc/freescale/wdt/: demo_kl26_hw_wdt.c
  group examples_std
    ../../../../examples/std/adc/: demo_std_adc.c demo_std_adc_ntc.c
    ../../../../examples/std/buzzer/: demo_std_buzzer.c
    ../../../../examples/std/cap/: demo_std_timer_cap.c
    ../../../../examples/std/crc/: demo_std_crc.c
    ../../../../examples/std/delay/: demo_std_delay.c
    ../../../../examples/std/digitron/: demo_std_digitron_60s_counting.c demo_std_digitron_temp.c
    ../../../../examples/std/gpio/: demo_std_gpio.c demo_std_gpio_trigger.c
    ../../../../examples/std/hc595/: demo_std_hc595_led.c
    ../../../../examples/std/i2c/: demo_std_i2c_lm75.c demo_std_i2c_master_async.c demo_std_i2c_master_sync.c demo_std_i2c_slave.c demo_std_i2c_slave_subaddr.c
    ../../../../examples/std/input/: demo_std_4key.c demo_std_key.c demo_std_key_digitron.c demo_std_key_digitron_rngbuf.c
    ../../../../examples/std/led/: demo_std_led.c demo_std_led_water_light.c
    ../../../../examples/std/nvram/: demo_std_nvram.c
    ../../../../examples/std/pwm/: demo_std_timer_pwm.c
    ../../../../examples/std/rtc/: demo_std_rtc.c
    ../../../../examples/std/softimer/: demo_std_softimer.c
    ../../../../examples/std/spi/: demo_std_spi_flash.c demo_std_spi_master.c demo_std_spi_slave.c
    ../../../../examples/std/timer/: demo_std_timer_timing.c
    ../../../../examples/std/uart/: demo_std_uart_polling.c demo_std_uart_ringbuf.c demo_std_uart_rs485.c
    ../../../../examples/std/wdt/: demo_std_wdt.c
  group startup
    ../startup/: am_kl26_armcc_system_init.c am_kl26_armcc_startup.s
  group user_code
    ../user_code/: main.c
  group user_config
    ../user_config/: am_prj_config.h am_board.h am_board.c am_prj_config.c
    ../user_config/am_hwconf_usrcfg/: am_hwconf_arm_nvic.c am_hwconf_buzzer_pwm.c am_hwconf_debug_uart.c am_hwconf_key_gpio.c am_hwconf_kl26_adc0.c am_hwconf_kl26_clk.c am_hwconf_kl26_dac0.c am_hwconf_kl26_dma.c am_hwconf_kl26_gpio.c am_hwconf_kl26_i2c0.c am_hwconf_kl26_i2c1.c am_hwconf_kl26_lptmr_timing.c am_hwconf_kl26_pit_timing.c am_hwconf_kl26_pmu.c am_hwconf_kl26_rtc.c am_hwconf_kl26_spi0_dma.c am_hwconf_kl26_spi0_int.c am_hwconf_kl26_spi1_dma.c am_hwconf_kl26_spi1_int.c am_hwconf_kl26_systick.c am_hwconf_kl26_tpm0_cap.c am_hwconf_kl26_tpm0_pwm.c am_hwconf_kl26_tpm0_timing.c am_hwconf_kl26_tpm1_cap.c am_hwconf_kl26_tpm1_pwm.c am_hwconf_kl26_tpm1_timing.c am_hwconf_kl26_tpm2_cap.c am_hwconf_kl26_tpm2_pwm.c am_hwconf_kl26_tpm2_timing.c am_hwconf_kl26_tsi.c am_hwconf_kl26_uart0.c am_hwconf_kl26_uart1.c am_hwconf_kl26_uart2.c am_hwconf_kl26_wdt.c am_hwconf_led_gpio.c am_hwconf_lm75.c am_hwconf_microport_ds1302.c am_hwconf_microport_eeprom.c am_hwconf_microport_flash.c am_hwconf_microport_rs485.c am_hwconf_microport_rtc.c am_hwconf_microport_rx8025t.c am_hwconf_miniport_595.c am_hwconf_miniport_key.c am_hwconf_miniport_led.c am_hwconf_miniport_view.c am_hwconf_miniport_view_key.c am_hwconf_miniport_zlg72128.c am_hwconf_system_tick_softimer.c am_hwconf_fm175xx.c am_hwconf_kl26_spi0_poll.c
    ../user_config/am_servconf_usrcfg/: am_servconf_nvram.c am_servconf_event_input.c
target release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKL16Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: as above
  output: template_amks16z_core +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG,AM_CORTEX_M0,KL16,CRP_ENABLE
  c include: .\user_code;.\user_config\am_hwconf_usrcfg;.\user_config\am_servconf_usrcfg;.\user_config;..\..\..\..\3rdparty\CMSIS\Include;..\..\..\..\arch\arm\include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\armlib_adapter\include;..\..\..\..\components\libc\microlib_adapter\include;..\..\..\..\components\service\include;..\..\..\..\components\util\include;..\..\..\..\interface;..\..\..\..\soc\freescale\drivers\include\adc;..\..\..\..\soc\freescale\drivers\include\bme;..\..\..\..\soc\freescale\drivers\include\clk;..\..\..\..\soc\freescale\drivers\include\cmp;..\..\..\..\soc\freescale\drivers\include\dac;..\..\..\..\soc\freescale\drivers\include\dma;..\..\..\..\soc\freescale\drivers\include\ftfa;..\..\..\..\soc\freescale\drivers\include\gpio;..\..\..\..\soc\freescale\drivers\include\i2c;..\..\..\..\soc\freescale\drivers\include\i2s;..\..\..\..\soc\freescale\drivers\include\llwu;..\..\..\..\soc\freescale\drivers\include\lptmr;..\..\..\..\soc\freescale\drivers\include\mcg;..\..\..\..\soc\freescale\drivers\include\mcm;..\..\..\..\soc\freescale\drivers\include\pinctr;..\..\..\..\soc\freescale\drivers\include\pit;..\..\..\..\soc\freescale\drivers\include\pmc;..\..\..\..\soc\freescale\drivers\include\pmu;..\..\..\..\soc\freescale\drivers\include\rcm;..\..\..\..\soc\freescale\drivers\include\rtc;..\..\..\..\soc\freescale\drivers\include\sim;..\..\..\..\soc\freescale\drivers\include\smc;..\..\..\..\soc\freescale\drivers\include\spi;..\..\..\..\soc\freescale\drivers\include\tpm;..\..\..\..\soc\freescale\drivers\include\tsi;..\..\..\..\soc\freescale\drivers\include\uart;..\..\..\..\soc\freescale\drivers\include\wdt;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config\am_servconf_usrcfg;..\..\..\bsp_common\include;..\..\..\..\examples\board;..\..\..\..\examples\components;..\..\..\..\examples\soc\freescale;..\..\..\..\examples\std;..\..\..\..\examples\board\amks16z_core;..\..\..\..\soc\freescale\kl26;..\..\..\..\examples\board\amks16rfid;..\..\..\..\examples\board\amks16rfid-8
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: ..\..\..\amks16rfid\project_example\projects_keil5\example_amks16rfid.sct
  link misc: --remove

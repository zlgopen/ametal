# Keil uVision project demo_hc32f460_core_application.uvprojx, settings and files
target debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.1
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003C0) IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo_hc32f460_core_application +hex
  AfterMake: fromelf --bincombined -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M4,__DEBUG,HC32F46x,USE_DEVICE_DRIVER_LIB APP
  c include: ..\user_code;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config\am_servconf_usrcfg;..\..\..\..\..\3rdparty\CMSIS\Include;..\..\..\..\..\arch\arm\include;..\..\..\..\bsp_common\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\service\include;..\..\..\..\..\components\util\include;..\..\..\..\..\examples\components;..\..\..\..\..\examples\soc\hdsc;..\..\..\..\..\examples\std;..\..\..\..\..\interface;..\..\..\bsp_common\include;..\user_config;..\..\..\..\..\arch\arm\include\hw;..\..\..\..\..\examples\components;..\..\..\..\..\components\libc\newlib_adapter\include;..\..\..\..\..\components\libc\armlib_adapter\include;..\..\..\..\..\components\libc\microlib_adapter\include;..\..\..\..\..\components\libc\newlib_adapter\include;..\..\..\..\..\components\usb\device;..\..\..\..\..\components\usb\include;..\..\..\..\..\components\usb\osa;..\..\..\..\..\components\usb\host\config;..\..\..\..\..\components\usb\host\common\include;..\..\..\..\..\components\usb\host\class\include;..\..\..\..\..\components\usb\device\config\include;..\..\..\..\..\components\usb\host;..\..\..\..\..\soc\zlg\drivers\include\syscfg;..\..\..\..\..\components\drivers\source\lcd;..\..\..\..\..\components\usb;..\..\..\..\..\components\usb\osa;..\..\..\..\..\components\usb\include;..\..\..\..\..\components\usb\device;..\..\..\..\..\components\usb\device\common\include;..\..\..\..\..\components\usb\device\class\include;..\..\..\..\..\components\usb\osa;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\bootloader\include\arch\arm;..\..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool;..\..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool\drivers;..\..\..\..\..\components\bootloader\include\core;..\..\..\..\..\components\bootloader\include\drivers;..\startup\common;..\user_code\driver\inc;..\..\..\..\..\soc\hdsc\drivers\include\clk;..\..\..\..\..\soc\hdsc\drivers\include\flash;..\..\..\..\..\soc\hdsc\drivers\include\gpio;..\..\..\..\..\soc\hdsc\drivers\include\uart;..\..\..\..\..\soc\hdsc\drivers\include\rcc;..\..\..\..\..\examples\board\amhc32f460_core;..\..\..\..\..\examples\board\amhc32f460_core;..\..\..\..\..\examples\soc\hdsc;..\..\..\..\..\soc\hdsc\drivers\include\tim;..\..\..\..\..\soc\hdsc\drivers\include\adc;..\..\..\..\..\soc\hdsc\drivers\include\adtim;..\..\..\..\..\soc\hdsc\drivers\include\aes;..\..\..\..\..\soc\hdsc\drivers\include\qspi;..\..\..\..\..\soc\hdsc\drivers\include\can;..\..\..\..\..\soc\hdsc\drivers\include\crc;..\..\..\..\..\soc\hdsc\drivers\include\dma;..\..\..\..\..\soc\hdsc\drivers\include\flash;..\..\..\..\..\soc\hdsc\drivers\include\i2c;..\..\..\..\..\soc\hdsc\drivers\include\rtc;..\..\..\..\..\soc\hdsc\drivers\include\sdio;..\..\..\..\..\soc\hdsc\drivers\include\spi;..\..\..\..\..\soc\hdsc\drivers\include\trng;..\..\..\..\..\soc\hdsc\drivers\include\usbd;..\..\..\..\..\soc\hdsc\drivers\include\wdt;..\..\..\..\..\soc\hdsc\drivers\include\qspi;..\..\..\..\..\soc\hdsc\drivers\include\mpu;..\..\..\..\..\soc\hdsc\drivers\include\hash;..\..\..\..\..\soc\hdsc\drivers\include\dcu;..\..\..\..\..\soc\hdsc\hc32f460;..\..\..\..\..\soc\hdsc\drivers\include\cmp;..\..\..\..\..\soc\hdsc\drivers\include\usbd\hw;..\..\..\..\..\soc\hdsc\drivers\source\usbd\internal_usb_core\usbd_dev\source;..\..\..\..\..\soc\hdsc\drivers\source\usbd\internal_usb_core\usb_lib\device_core;..\..\..\..\..\soc\hdsc\drivers\source\usbd\internal_usb_core\usb_lib\ctl_drv;..\..\..\..\..\soc\hdsc\drivers\source\usbd\internal_usb_core\usb_lib\device_class;..\..\..\..\..\soc\hdsc\drivers\source\usbd\internal_usb_core\usb_lib\device_class\msc;..\..\..\..\..\soc\hdsc\drivers\source\usbd\internal_usb_core\usb_lib\device_class\hid_mouse;..\..\..\..\..\soc\hdsc\drivers\source\usbd\internal_usb_core\usb_lib\device_class\hid_custom;..\..\..\..\..\soc\hdsc\drivers\include\bootloader;..\user_config\am_bootconf_usrcfg;..\..\..\..\..\examples\components\bootloader;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\bootloader\include\arch\arm;..\..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool;..\..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool\drivers;..\..\..\..\..\components\bootloader\include\core;..\..\..\..\..\components\bootloader\include\drivers;..\user_config\am_bootconf_usrcfg
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x78000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x20000000 size 0xffff
  memory RVCT10: RAM 0x20010000 size 0xffff
  scatter file: .\demo_hc32f460_core_application.sct
  group bsp_common
    ../../../../bsp_common/source/: am_bsp_armlib.c am_bsp_microlib.c am_bsp_delay_timer.c am_bsp_system_heap.c am_bsp_isr_defer_pendsv.c
  group arm
    ../../../../../arch/arm/source/: am_arm_nvic.c am_arm_nvic_armcc.s am_arm_systick.c
  group drivers
    ../../../../../components/drivers/source/adc/: am_cs1237.c
    ../../../../../components/drivers/source/ble/: am_zlg9021.c
    ../../../../../components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../../../../../components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../../../../../components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../../../../../components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../../../../../components/drivers/source/digitron_key/: am_zlg72128_std.c zlg72128.c zlg72128_platform.c
    ../../../../../components/drivers/source/fingerprint/: am_ts10x.c
    ../../../../../components/drivers/source/flash/: am_mx25xx.c
    ../../../../../components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../../../../../components/drivers/source/i2c/: am_i2c_gpio.c
    ../../../../../components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../../../../../components/drivers/source/led/: am_led_gpio.c am_led_hc595.c
    ../../../../../components/drivers/source/miniport/: am_miniport_view_key.c am_miniport_view_key_595.c
    ../../../../../components/drivers/source/nvram/: am_ep24cxx.c
    ../../../../../components/drivers/source/rtc/: am_ds1302.c am_pcf85063.c am_rx8025sa.c am_rx8025t.c
    ../../../../../components/drivers/source/sht20/: am_sht20.c
    ../../../../../components/drivers/source/spi/: am_spi_gpio.c
    ../../../../../components/drivers/source/temperature/: am_temp_lm75.c
    ../../../../../components/drivers/source/uart/: am_sc16is7xx.c
    ../../../../../components/drivers/source/zigbee/: am_zm516x.c
    ../../../../../components/drivers/source/zlg600/: am_zlg600.c
    ../../../../../components/drivers/source/lcd/: am_ili9341.c am_ili9341_intfc_3wire.c
    ../../../../../components/drivers/source/sdcard/: am_sdcard.c
    ../../../../../components/usb/: am_usbd_lib_m4.lib
  group libc
    ../../../../../components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../../../../../components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../../../../../components/service/source/: am_adc.c am_buzzer_dev.c am_event_category_input.c am_dac.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_timer.c am_uart.c am_uart_rngbuf.c am_sdio.c
  group util
    ../../../../../components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c
  group soc
    ../../../../../soc/hdsc/drivers/source/clk/: am_hc32f460_clk.c
    ../../../../../soc/hdsc/drivers/source/flash/: am_hc32f460_flash.c
    ../../../../../soc/hdsc/drivers/source/gpio/: am_hc32f460_gpio.c
    ../../../../../soc/hdsc/drivers/source/uart/: am_hc32f460_uart.c
    ../../../../../soc/hdsc/drivers/source/uart/hw/: amhw_hc32f460_uart.c
    ../../../../../soc/hdsc/drivers/source/rcc/hw/: amhw_hc32f460_rcc.c
    ../../../../../soc/hdsc/hc32f460/: hc32f460_irq_handle.c hc32f460_icg.c
    ../../../../../soc/hdsc/drivers/source/adtim/: am_hc32f460_adtim_cap.c am_hc32f460_adtim_pwm.c am_hc32f460_adtim_timing.c
    ../../../../../soc/hdsc/drivers/source/aes/: am_hc32f460_aes.c
    ../../../../../soc/hdsc/drivers/source/can/: am_hc32f460_can.c
    ../../../../../soc/hdsc/drivers/source/dma/: am_hc32f460_dma.c
    ../../../../../soc/hdsc/drivers/source/hash/: am_hc32f460_hash.c
    ../../../../../soc/hdsc/drivers/source/i2c/: am_hc32f460_i2c.c am_hc32f460_i2c_slv.c
    ../../../../../soc/hdsc/drivers/source/qspi/: am_hc32f460_qspi.c
    ../../../../../soc/hdsc/drivers/source/rtc/: am_hc32f460_rtc.c
    ../../../../../soc/hdsc/drivers/source/sdio/: am_hc32f460_sdioc.c
    ../../../../../soc/hdsc/drivers/source/spi/: am_hc32f460_spi_dma.c am_hc32f460_spi_int.c am_hc32f460_spi_poll.c am_hc32f460_spi_slv_dma.c
    ../../../../../soc/hdsc/drivers/source/tim/: am_hc32f460_tim_timing.c am_hc32f460_tim4_pwm.c am_hc32f460_tim4_timing.c am_hc32f460_timea_cap.c am_hc32f460_timea_pwm.c am_hc32f460_timea_timing.c
    ../../../../../soc/hdsc/drivers/source/adc/: am_hc32f460_adc.c
    ../../../../../soc/hdsc/drivers/source/trng/: am_hc32f460_trng.c
    ../../../../../soc/hdsc/drivers/source/wdt/: am_hc32f460_swdt.c am_hc32f460_wdt.c
    ../../../../../soc/hdsc/drivers/source/adtim/hw/: amhw_hc32f460_adtim.c
    ../../../../../soc/hdsc/drivers/source/crc/: am_hc32f460_crc.c
    ../../../../../soc/hdsc/drivers/source/usbd/: am_hc32f460_usbd.c
    ../../../../../soc/hdsc/drivers/source/usbd/internal_usb_core/usb_lib/ctl_drv/: usb_core.c usb_dcd.c usb_dcd_int.c usb_otg.c
    ../../../../../soc/hdsc/drivers/source/usbd/internal_usb_core/usb_lib/device_class/msc/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
    ../../../../../soc/hdsc/drivers/source/usbd/internal_usb_core/usb_lib/device_core/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../../../../soc/hdsc/drivers/source/usbd/internal_usb_core/usb_lib/device_class/hid_mouse/: usbd_hid_mouse_core.c
    ../../../../../soc/hdsc/drivers/source/usbd/internal_usb_core/usbd_dev/source/: usb_bsp_template.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
    ../../../../../soc/hdsc/drivers/source/usbd/internal_usb_core/usb_lib/device_class/hid_custom/: usbd_hid_custom_core.c
    ../../../../../soc/hdsc/drivers/source/bootloader/: am_hc32f460_boot_flash.c
  group startup
    ../startup/: am_hc32f460_armcc_startup.s am_hc32f460_armcc_sys.c
  group user_code
    ../user_code/: main.c
  group user_config
    ../user_config/: am_board.c am_prj_config.c am_board.h am_hc32f460_inst_init.h am_prj_config.h
    ../user_config/am_servconf_usrcfg/: am_servconf_event_input.c am_servconf_nvram.c am_service_inst_init.h
    ../user_config/am_hwconf_usrcfg/: am_hwconf_arm_nvic.c am_hwconf_debug_uart.c am_hwconf_hc32f460_clk.c am_hwconf_hc32f460_gpio.c am_hwconf_hc32f460_systick.c am_hwconf_hc32f460_uart.c am_hwconf_hc32f460_adc.c am_hwconf_hc32f460_adtim_cap.c am_hwconf_hc32f460_adtim_pwm.c am_hwconf_hc32f460_adtim_timing.c am_hwconf_hc32f460_aes.c am_hwconf_hc32f460_can.c am_hwconf_hc32f460_dma.c am_hwconf_hc32f460_hash.c am_hwconf_hc32f460_i2c.c am_hwconf_hc32f460_led_gpio.c am_hwconf_hc32f460_qspi.c am_hwconf_hc32f460_rtc.c am_hwconf_hc32f460_sdcard.c am_hwconf_hc32f460_sdioc.c am_hwconf_hc32f460_spi_dma.c am_hwconf_hc32f460_spi_int.c am_hwconf_hc32f460_spi_poll.c am_hwconf_hc32f460_spi_slv_dma.c am_hwconf_hc32f460_swdt.c am_hwconf_hc32f460_tim_timing.c am_hwconf_hc32f460_tim4_pwm.c am_hwconf_hc32f460_tim4_timing.c am_hwconf_hc32f460_timea_cap.c am_hwconf_hc32f460_timea_pwm.c am_hwconf_hc32f460_timea_timing.c am_hwconf_hc32f460_trng.c am_hwconf_hc32f460_wdt.c am_hwconf_system_tick_softimer.c am_hwconf_hc32f460_crc.c am_hwconf_hc32f460_usb_msc.c am_hwconf_hc32f460_i2c_slv.c am_hwconf_key_gpio.c am_hwconf_hc32f460_usb_mouse.c am_usb_common_config.h am_hwconf_hc32f460_usb_custom.c
    ../user_config/am_bootconf_usrcfg/: am_appconf_double_hc32f460.c am_appconf_hc32f460_clk.c
  group examples_board
    ../../../../../examples/board/amhc32f460_core/adc/: demo_hc32f460_core_hw_adc_awd.c demo_hc32f460_core_hw_adc_dma.c demo_hc32f460_core_hw_adc_int.c demo_hc32f460_core_hw_adc_pga.c demo_hc32f460_core_hw_adc_seq_a_b_event_trigger.c demo_hc32f460_core_hw_adc_seq_a_event_trigger.c demo_hc32f460_core_hw_adc_sync.c demo_hc32f460_core_hw_multichan_adc.c demo_hc32f460_core_hw_multichan_seq_adc.c demo_hc32f460_core_std_adc.c demo_hc32f460_core_std_multichan_adc.c
    ../../../../../examples/board/amhc32f460_core/aes/: demo_hc32f460_core_drv_aes_ency_decy.c demo_hc32f460_core_hw_aes_ency_decy.c
    ../../../../../examples/board/amhc32f460_core/can/: demo_hc32f460_core_std_can.c
    ../../../../../examples/board/amhc32f460_core/dcu/: demo_hc32f460_core_hw_dcu.c
    ../../../../../examples/board/amhc32f460_core/dma/: demo_hc32f460_core_drv_dma_m2m.c demo_hc32f460_core_drv_dma_m2m_chain.c
    ../../../../../examples/board/amhc32f460_core/gpio/: demo_hc32f460_core_hw_gpio.c demo_hc32f460_core_hw_gpio_trigger.c demo_hc32f460_core_std_gpio.c demo_hc32f460_core_std_gpio_trigger.c
    ../../../../../examples/board/amhc32f460_core/hash/: demo_hc32f460_core_drv_hash.c demo_hc32f460_core_hw_hash.c
    ../../../../../examples/board/amhc32f460_core/i2c/: demo_hc32f460_core_hw_i2c_master_poll.c demo_hc32f460_core_hw_i2c_slave_poll.c demo_hc32f460_core_std_i2c_master_async.c demo_hc32f460_core_std_i2c_master_sync.c demo_hc32f460_core_std_i2c_slave_int.c
    ../../../../../examples/board/amhc32f460_core/led/: demo_hc32f460_core_std_led.c
    ../../../../../examples/board/amhc32f460_core/mpu/: demo_hc32f460_core_hw_mpu.c
    ../../../../../examples/board/amhc32f460_core/qspi/: demo_hc32f460_core_drv_qspi.c
    ../../../../../examples/board/amhc32f460_core/rtc/: demo_hc32f460_core_std_rtc.c
    ../../../../../examples/board/amhc32f460_core/sdcard/: demo_hc32f460_core_std_sdcard.c
    ../../../../../examples/board/amhc32f460_core/spi/: demo_hc32f460_core_hw_spi_master.c demo_hc32f460_core_std_spi_master_dma.c demo_hc32f460_core_std_spi_master_int.c demo_hc32f460_core_std_spi_master_poll.c demo_hc32f460_core_std_spi_slaver_dma.c
    ../../../../../examples/board/amhc32f460_core/timer/: demo_hc32f460_core_std_adtim61_cap.c demo_hc32f460_core_std_adtim61_pwm.c demo_hc32f460_core_std_adtim61_timing.c demo_hc32f460_core_std_adtim62_cap.c demo_hc32f460_core_std_adtim62_pwm.c demo_hc32f460_core_std_adtim62_timing.c demo_hc32f460_core_std_adtim63_cap.c demo_hc32f460_core_std_adtim63_pwm.c demo_hc32f460_core_std_adtim63_timing.c demo_hc32f460_core_std_tim01_timing.c demo_hc32f460_core_std_tim02_timing.c demo_hc32f460_core_std_tim41_pwm.c demo_hc32f460_core_std_tim41_timing.c demo_hc32f460_core_std_tim42_pwm.c demo_hc32f460_core_std_tim42_timing.c demo_hc32f460_core_std_tim43_pwm.c demo_hc32f460_core_std_tim43_timing.c demo_hc32f460_core_std_timea1_cap.c demo_hc32f460_core_std_timea1_pwm.c demo_hc32f460_core_std_timea1_timing.c demo_hc32f460_core_std_timea2_cap.c demo_hc32f460_core_std_timea2_pwm.c demo_hc32f460_core_std_timea2_timing.c demo_hc32f460_core_std_timea3_cap.c demo_hc32f460_core_std_timea3_pwm.c demo_hc32f460_core_std_timea3_timing.c demo_hc32f460_core_std_timea4_cap.c demo_hc32f460_core_std_timea4_pwm.c demo_hc32f460_core_std_timea4_timing.c demo_hc32f460_core_std_timea5_cap.c demo_hc32f460_core_std_timea5_pwm.c demo_hc32f460_core_std_timea5_timing.c demo_hc32f460_core_std_timea6_cap.c demo_hc32f460_core_std_timea6_pwm.c demo_hc32f460_core_std_timea6_timing.c
    ../../../../../examples/board/amhc32f460_core/trng/: demo_hc32f460_core_drv_trng_generate.c demo_hc32f460_core_hw_trng_generate.c
    ../../../../../examples/board/amhc32f460_core/uart/: demo_hc32f460_core_hw_uart_int.c demo_hc32f460_core_hw_uart_polling.c demo_hc32f460_core_hw_uart_rx_dma.c demo_hc32f460_core_hw_uart_tx_dma.c demo_hc32f460_core_std_uart_polling.c demo_hc32f460_core_std_uart_ringbuf.c
    ../../../../../examples/board/amhc32f460_core/wdt/: demo_hc32f460_core_drv_swdt_int.c demo_hc32f460_core_drv_wdt_int.c demo_hc32f460_core_hw_wdt.c demo_hc32f460_core_std_wdt.c
    ../../../../../examples/board/amhc32f460_core/clk/: demo_hc32f460_core_hw_clk.c
    ../../../../../examples/board/amhc32f460_core/crc/: demo_hc32f460_core_std_crc.c
    ../../../../../examples/board/amhc32f460_core/flash/: demo_hc32f460_core_drv_flash.c
    ../../../../../examples/board/amhc32f460_core/usbd/: demo_hc32f460_core_usbd_msc.c demo_hc32f460_core_usbd_mouse.c demo_hc32f460_core_usbd_hid_custom.c
    ../../../../../examples/board/amhc32f460_core/input_event/: demo_hc32f460_core_std_key_input_event.c
    ../../../../../examples/board/amhc32f460_core/bootloader/: demo_hc32f460_core_single_application.c demo_hc32f460_core_double_uart_application.c
  group examples_soc
    ../../../../../examples/soc/hdsc/adc/: demo_hc32f460_hw_adc_awd.c demo_hc32f460_hw_adc_dma.c demo_hc32f460_hw_adc_int.c demo_hc32f460_hw_adc_pga.c demo_hc32f460_hw_adc_seq_a_b_event_trigger.c demo_hc32f460_hw_adc_seq_a_event_trigger.c demo_hc32f460_hw_adc_sync.c demo_hc32f460_hw_multichan_adc.c demo_hc32f460_hw_multichan_seq_adc.c
    ../../../../../examples/soc/hdsc/aes/: demo_hc32f460_drv_aes_ency_decy.c demo_hc32f460_hw_aes_ency_decy.c
    ../../../../../examples/soc/hdsc/dcu/: demo_hc32f460_hw_dcu.c
    ../../../../../examples/soc/hdsc/dma/: demo_hc32f460_drv_dma_m2m.c demo_hc32f460_drv_dma_m2m_chain.c
    ../../../../../examples/soc/hdsc/gpio/: demo_hc32f460_hw_gpio.c demo_hc32f460_hw_gpio_trigger.c
    ../../../../../examples/soc/hdsc/hash/: demo_hc32f460_drv_hash.c demo_hc32f460_hw_hash.c
    ../../../../../examples/soc/hdsc/i2c/: demo_hc32f460_hw_i2c_master_poll.c demo_hc32f460_hw_i2c_slave_poll.c
    ../../../../../examples/soc/hdsc/mpu/: demo_hc32f460_hw_mpu.c
    ../../../../../examples/soc/hdsc/qspi/: demo_hc32f460_drv_qspi.c
    ../../../../../examples/soc/hdsc/spi/: demo_hc32f460_hw_spi_master.c
    ../../../../../examples/soc/hdsc/trng/: demo_hc32f460_drv_trng_generate.c demo_hc32f460_hw_trng_generate.c
    ../../../../../examples/soc/hdsc/uart/: demo_hc32f460_hw_uart_int.c demo_hc32f460_hw_uart_polling.c demo_hc32f460_hw_uart_rx_dma.c demo_hc32f460_hw_uart_tx_dma.c
    ../../../../../examples/soc/hdsc/wdg/: demo_hc32f460_drv_swdt_int.c demo_hc32f460_drv_wdt_int.c demo_hc32f460_hw_wdt.c
    ../../../../../examples/soc/hdsc/clk/: demo_hc32f460_hw_clk.c
    ../../../../../examples/soc/hdsc/flash/: demo_hc32f460_drv_flash.c
    ../../../../../examples/soc/hdsc/usbd/: demo_usbd_msc.c demo_usbd_mouse.c demo_usbd_hid_custom.c
  group examples_std
    ../../../../../examples/std/adc/: demo_std_adc.c demo_std_adc_its.c demo_std_adc_ntc.c demo_std_multichan_adc.c
    ../../../../../examples/std/buzzer/: demo_std_buzzer.c
    ../../../../../examples/std/can/: demo_std_can.c
    ../../../../../examples/std/cap/: demo_std_timer_cap.c
    ../../../../../examples/std/crc/: demo_std_crc.c
    ../../../../../examples/std/dac/: demo_std_dac.c
    ../../../../../examples/std/delay/: demo_std_delay.c
    ../../../../../examples/std/gpio/: demo_std_gpio.c demo_std_gpio_trigger.c
    ../../../../../examples/std/i2c/: demo_std_i2c_master_async.c demo_std_i2c_master_sync.c demo_std_i2c_slave.c
    ../../../../../examples/std/input/: demo_std_key.c demo_std_key_digitron.c demo_std_key_digitron_rngbuf.c
    ../../../../../examples/std/led/: demo_std_led.c demo_std_led_water_light.c
    ../../../../../examples/std/nvram/: demo_std_nvram.c
    ../../../../../examples/std/pwm/: demo_std_timer_pwm.c
    ../../../../../examples/std/rtc/: demo_std_rtc.c
    ../../../../../examples/std/sdcard/: demo_std_sdcard.c
    ../../../../../examples/std/softimer/: demo_std_softimer.c
    ../../../../../examples/std/spi/: demo_std_spi_flash.c demo_std_spi_master.c demo_std_spi_slave.c
    ../../../../../examples/std/timer/: demo_std_timer_timing.c
    ../../../../../examples/std/uart/: demo_std_uart_polling.c demo_std_uart_ringbuf.c demo_std_uart_rs485.c
    ../../../../../examples/std/wdt/: demo_std_wdt.c
    ../../../../../examples/components/bootloader/: demo_std_double_application.c
  group bootloader
    ../../../../../components/bootloader/source/arch/arm/: am_arm_boot.c
    ../../../../../components/bootloader/source/drivers/: am_boot.c am_boot_enter_check_key.c am_boot_enter_check_uart.c am_boot_enter_check_uart_cmd.c am_boot_firmware_flash.c am_boot_firmware_recv_uart.c am_boot_mem_flash.c am_boot_msg_flag.c am_boot_serial_uart.c
target release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.1
  cpu: as above
  output: template_am159 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M4,__DEBUG,HC32F46x,USE_DEVICE_DRIVER_LIB,__FPU_PRESENT
  c include: ..\user_code;..\user_config;..\user_config\am_servconf_usrcfg;..\..\..\..\..\3rdparty\CMSIS\Include;..\..\..\..\..\arch\arm\include;..\..\..\bsp_common\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\service\include;..\..\..\..\..\components\util\include;..\..\..\..\..\examples\components;..\..\..\..\..\examples\soc\hdsc;..\..\..\..\..\examples\std;..\..\..\..\..\interface;..\user_config\am_hwconf_usrcfg;..\..\..\..\..\soc\hdsc\drivers\include\adc;..\..\..\..\..\soc\hdsc\drivers\include\clk;..\..\..\..\..\soc\hdsc\drivers\include\crc;..\..\..\..\..\soc\hdsc\drivers\include\dma;..\..\..\..\..\soc\hdsc\drivers\include\flash\hw;..\..\..\..\..\soc\hdsc\drivers\include\gpio;..\..\..\..\..\soc\hdsc\drivers\include\i2c;..\..\..\..\..\soc\hdsc\drivers\include\rcc;..\..\..\..\..\soc\hdsc\drivers\include\spi;..\..\..\..\..\soc\hdsc\drivers\include\tim;..\..\..\..\..\soc\hdsc\drivers\include\uart;..\..\..\..\..\soc\hdsc\drivers\include\wdt;..\..\..\bsp_common\include;..\user_config;..\..\..\..\..\soc\hdsc\drivers\include\gpio\hw;..\..\..\..\..\soc\hdsc\drivers\include\rtc\hw;..\..\..\..\..\soc\hdsc\drivers\include\rcc\hw;..\..\..\hc32f460_core;..\..\..\..\..\soc\hdsc\drivers\include\adc;..\..\..\..\..\soc\hdsc\drivers\include\adc\hw;..\..\..\..\..\soc\hdsc\drivers\include\uart\hw;..\..\..\..\..\soc\hdsc\drivers\include\flash;..\..\..\..\..\soc\hdsc\drivers\include\crc\hw;..\..\..\..\..\soc\hdsc\drivers\include\dac\hw;..\..\..\..\..\soc\hdsc\drivers\include\dma\hw;..\..\..\..\..\soc\hdsc\drivers\include\i2c\hw;..\..\..\..\..\soc\hdsc\drivers\include\wdt\hw;..\..\..\..\..\soc\hdsc\drivers\include\spi\hw;..\..\..\..\..\soc\hdsc\drivers\include\tim\hw;..\..\..\..\..\arch\arm\include\hw;..\..\..\..\..\soc\hdsc\drivers\include\rtc;..\..\..\..\..\examples\components;..\..\..\..\..\components\libc\newlib_adapter\include;..\..\..\..\..\components\libc\armlib_adapter\include;..\..\..\..\..\components\libc\microlib_adapter\include;..\..\..\..\..\components\libc\newlib_adapter\include;..\..\..\..\..\soc\hdsc\drivers\include\can;..\..\..\..\..\soc\hdsc\drivers\include\can\hw;..\..\..\..\..\soc\hdsc\drivers\include\usbd;..\..\..\..\..\soc\hdsc\drivers\include\usbd\hw;..\..\..\..\..\components\usb\device;..\..\..\..\..\components\usb\include;..\..\..\..\..\components\usb\osa;..\..\..\..\..\components\usb\host\config;..\..\..\..\..\components\usb\host\common\include;..\..\..\..\..\components\usb\host\class\include;..\..\..\..\..\components\usb\device\config\include;..\..\..\..\..\components\usb\host;..\..\..\..\..\components\drivers\source\lcd;..\..\..\..\..\soc\hdsc\hc32f460;..\..\..\..\..\soc\hdsc\drivers\include\qspi;..\..\..\..\..\soc\hdsc\drivers\include\aes;..\..\..\..\..\soc\hdsc\drivers\include\sdio;..\..\..\..\..\soc\hdsc\drivers\include\mpu;..\..\..\..\..\soc\hdsc\drivers\include\hash;..\..\..\..\..\soc\hdsc\drivers\include\trng;..\..\..\..\..\soc\hdsc\drivers\include\adtim;..\..\..\..\..\soc\hdsc\drivers\include\dcu;..\..\..\..\..\examples\board\amhc32f460_core;..\..\..\..\..\soc\hdsc\drivers\include\cmp;..\..\..\..\..\components\usb\device\common\include;..\..\..\..\..\components\usb\device\class\include;..\..\..\..\..\components\usb;..\..\..\..\..\soc\hdsc\drivers\source\usbd\internal_usb_core\usbd_dev\source;..\..\..\..\..\soc\hdsc\drivers\source\usbd\internal_usb_core\usb_lib\ctl_drv;..\..\..\..\..\soc\hdsc\drivers\source\usbd\internal_usb_core\usb_lib\device_class\msc;..\..\..\..\..\soc\hdsc\drivers\source\usbd\internal_usb_core\usb_lib\device_core;..\..\..\..\..\soc\hdsc\drivers\source\usbd\internal_usb_core\usb_lib\device_class\hid_mouse;..\..\..\..\..\soc\hdsc\drivers\source\usbd\internal_usb_core\usb_lib\device_class\hid_custom;..\..\..\..\..\soc\hdsc\drivers\include\bootloader;..\user_config\am_bootconf_usrcfg;..\..\..\..\..\examples\components\bootloader;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\bootloader\include\arch\arm;..\..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool;..\..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool\drivers;..\..\..\..\..\components\bootloader\include\core;..\..\..\..\..\components\bootloader\include\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000

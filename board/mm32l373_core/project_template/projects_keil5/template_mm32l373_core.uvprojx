# Keil uVision project template_mm32l373_core.uvprojx, settings and files
target debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ZLG217 Generic
  pack: ZLG.ZLG200_DFP.1.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template_mm32l373 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M3
  c include: ..\user_code;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config\am_servconf_usrcfg;..\..\..\..\3rdparty\CMSIS\Include;..\..\..\..\arch\arm\include;..\..\..\bsp_common\include;..\..\..\..\components\drivers\include;..\..\..\..\components\service\include;..\..\..\..\components\util\include;..\..\..\..\examples\board\mm32l373_core;..\..\..\..\examples\components;..\..\..\..\examples\soc\mm32;..\..\..\..\examples\std;..\..\..\..\interface;..\..\..\..\soc\mm32\mm32l373;..\..\..\..\soc\mm32\drivers\include\adc;..\..\..\..\soc\mm32\drivers\include\bkp;..\..\..\..\soc\mm32\drivers\include\bkp\hw;..\..\..\..\soc\mm32\drivers\include\clk;..\..\..\..\soc\mm32\drivers\include\cmp;..\..\..\..\soc\mm32\drivers\include\crc;..\..\..\..\soc\mm32\drivers\include\dac;..\..\..\..\soc\mm32\drivers\include\dma;..\..\..\..\soc\mm32\drivers\include\exti;..\..\..\..\soc\mm32\drivers\include\flash\hw;..\..\..\..\soc\mm32\drivers\include\gpio;..\..\..\..\soc\mm32\drivers\include\i2c;..\..\..\..\soc\mm32\drivers\include\pwr;..\..\..\..\soc\mm32\drivers\include\rcc;..\..\..\..\soc\mm32\drivers\include\spi;..\..\..\..\soc\mm32\drivers\include\syscfg\hw;..\..\..\..\soc\mm32\drivers\include\tim;..\..\..\..\soc\mm32\drivers\include\uart;..\..\..\..\soc\mm32\drivers\include\wdt;..\..\..\bsp_common\include;..\user_config;..\..\..\..\soc\mm32\drivers\include\gpio\hw;..\..\..\..\soc\mm32\drivers\include\pwr\hw;..\..\..\..\soc\mm32\drivers\include\rtc\hw;..\..\..\..\soc\mm32\drivers\include\afio\hw;..\..\..\..\soc\mm32\drivers\include\rcc\hw;..\..\..\..\soc\mm32\drivers\include\exti\hw;..\..\..\mm32l373_core;..\..\..\..\soc\mm32\drivers\include\adc;..\..\..\..\soc\mm32\drivers\include\adc\hw;..\..\..\..\soc\mm32\drivers\include\uart\hw;..\..\..\..\soc\mm32\drivers\include\flash;..\..\..\..\soc\mm32\drivers\include\crc\hw;..\..\..\..\soc\mm32\drivers\include\dac\hw;..\..\..\..\soc\mm32\drivers\include\dma\hw;..\..\..\..\soc\mm32\drivers\include\i2c\hw;..\..\..\..\soc\mm32\drivers\include\wdt\hw;..\..\..\..\soc\mm32\drivers\include\spi\hw;..\..\..\..\soc\mm32\drivers\include\tim\hw;..\..\..\..\arch\arm\include\hw;..\..\..\..\soc\mm32\drivers\include\rtc;..\..\..\..\examples\components;..\..\..\..\components\libc\newlib_adapter\include;..\..\..\..\soc\mm32\drivers\include\ili9341;..\..\..\..\components\libc\armlib_adapter\include;..\..\..\..\components\libc\microlib_adapter\include;..\..\..\..\components\libc\newlib_adapter\include;..\..\..\..\soc\mm32\drivers\include\can;..\..\..\..\soc\mm32\drivers\include\can\hw;..\..\..\..\soc\mm32\drivers\include\usbd;..\..\..\..\soc\mm32\drivers\include\usbd\hw;..\..\..\..\components\usb\device;..\..\..\..\components\usb\include;..\..\..\..\components\usb\osa;..\..\..\..\components\usb\host\config;..\..\..\..\components\usb\host\common\include;..\..\..\..\components\usb\host\class\include;..\..\..\..\components\usb\device\config\include;..\..\..\..\components\usb\host;..\..\..\mm32l373_core;..\..\..\..\soc\mm32\drivers\include\syscfg;..\..\..\..\components\drivers\source\lcd;..\..\..\..\examples\std;..\..\..\..\examples\soc\mm32;..\..\..\..\examples\components
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group bsp_common
    ../../../bsp_common/source/: am_bsp_armlib.c am_bsp_microlib.c am_bsp_delay_timer.c am_bsp_system_heap.c am_bsp_isr_defer_pendsv.c
  group arm
    ../../../../arch/arm/source/: am_arm_nvic.c am_arm_nvic_armcc.s am_arm_systick.c
  group drivers
    ../../../../components/drivers/source/adc/: am_cs1237.c
    ../../../../components/drivers/source/ble/: am_zlg9021.c
    ../../../../components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../../../../components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../../../../components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../../../../components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../../../../components/drivers/source/digitron_key/: am_zlg72128.c am_zlg72128_std.c
    ../../../../components/drivers/source/fingerprint/: am_ts10x.c
    ../../../../components/drivers/source/flash/: am_mx25xx.c
    ../../../../components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../../../../components/drivers/source/i2c/: am_i2c_gpio.c
    ../../../../components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../../../../components/drivers/source/led/: am_led_gpio.c am_led_hc595.c
    ../../../../components/drivers/source/miniport/: am_miniport_view_key.c am_miniport_view_key_595.c
    ../../../../components/drivers/source/nvram/: am_ep24cxx.c
    ../../../../components/drivers/source/rtc/: am_ds1302.c am_pcf85063.c am_rx8025sa.c am_rx8025t.c
    ../../../../components/drivers/source/sht20/: am_sht20.c
    ../../../../components/drivers/source/spi/: am_spi_gpio.c
    ../../../../components/drivers/source/temperature/: am_temp_lm75.c
    ../../../../components/drivers/source/uart/: am_sc16is7xx.c
    ../../../../components/drivers/source/zigbee/: am_zm516x.c
    ../../../../components/drivers/source/zlg600/: am_zlg600.c
    ../../../../components/drivers/source/lcd/: am_ili9341.c am_ili9341_intfc_3wire.c
    ../../../../components/drivers/source/fm175xx/: am_fm175xx_zlg217.lib
  group libc
    ../../../../components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../../../../components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../../../../components/service/source/: am_adc.c am_buzzer_dev.c am_event_category_input.c am_dac.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_timer.c am_uart.c am_uart_rngbuf.c
  group util
    ../../../../components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c
  group soc
    ../../../../soc/mm32/drivers/source/adc/: am_mm32_adc.c
    ../../../../soc/mm32/drivers/source/crc/: am_mm32_crc.c
    ../../../../soc/mm32/drivers/source/dac/: am_mm32_dac.c
    ../../../../soc/mm32/drivers/source/dma/: am_mm32_dma.c
    ../../../../soc/mm32/drivers/source/flash/: am_mm32_flash.c
    ../../../../soc/mm32/drivers/source/i2c/: am_mm32_i2c.c am_mm32_i2c_slv.c
    ../../../../soc/mm32/drivers/source/spi/: am_mm32_spi_int.c am_mm32_spi_slv_dma.c am_mm32_spi_dma.c am_mm32_spi_poll.c
    ../../../../soc/mm32/drivers/source/tim/: am_mm32_tim_cap.c am_mm32_tim_pwm.c am_mm32_tim_timing.c
    ../../../../soc/mm32/drivers/source/uart/: am_mm32_uart.c
    ../../../../soc/mm32/drivers/source/uart/hw/: amhw_mm32_uart.c
    ../../../../soc/mm32/drivers/source/wdt/: am_mm32_iwdg.c am_mm32_wwdg.c
    ../../../../soc/mm32/drivers/source/rcc/hw/: amhw_mm32l373_rcc.c
    ../../../../soc/mm32/drivers/source/gpio/: am_mm32l373_gpio.c
    ../../../../soc/mm32/drivers/source/pwr/: am_mm32l373_pwr.c
    ../../../../soc/mm32/drivers/source/clk/: am_mm32l373_clk.c
    ../../../../soc/mm32/drivers/source/ili9341/: am_mm32_ili9341_3wire_spi.c
    ../../../../soc/mm32/drivers/source/rtc/: am_mm32l373_rtc.c
  group startup
    ../startup/: am_mm32l373_armcc_startup.s
  group user_code
    ../user_code/: main.c
  group user_config
    ../user_config/: am_prj_config.c am_board.c am_prj_config.h am_board.h am_mm32l373_inst_init.h
    ../user_config/am_hwconf_usrcfg/: am_hwconf_arm_nvic.c am_hwconf_buzzer_pwm.c am_hwconf_debug_uart.c am_hwconf_key_gpio.c am_hwconf_lcd_ili9341.c am_hwconf_led_gpio.c am_hwconf_lm75.c am_hwconf_microport_ds1302.c am_hwconf_microport_eeprom.c am_hwconf_microport_flash.c am_hwconf_microport_rs485.c am_hwconf_microport_rtc.c am_hwconf_microport_rx8025t.c am_hwconf_miniport_595.c am_hwconf_miniport_key.c am_hwconf_miniport_led.c am_hwconf_miniport_view.c am_hwconf_miniport_view_key.c am_hwconf_miniport_zlg72128.c am_hwconf_system_tick_softimer.c am_hwconf_fm175xx.c am_hwconf_mm32l373_adc.c am_hwconf_mm32l373_clk.c am_hwconf_mm32l373_crc.c am_hwconf_mm32l373_dac.c am_hwconf_mm32l373_dma.c am_hwconf_mm32l373_gpio.c am_hwconf_mm32l373_i2c.c am_hwconf_mm32l373_i2c_slv.c am_hwconf_mm32l373_iwdg.c am_hwconf_mm32l373_pwr.c am_hwconf_mm32l373_rtc.c am_hwconf_mm32l373_spi_dma.c am_hwconf_mm32l373_spi_int.c am_hwconf_mm32l373_spi_poll.c am_hwconf_mm32l373_systick.c am_hwconf_mm32l373_tim_cap.c am_hwconf_mm32l373_tim_pwm.c am_hwconf_mm32l373_tim_timing.c am_hwconf_mm32l373_uart.c am_hwconf_mm32l373_wwdg.c
    ../user_config/am_servconf_usrcfg/: am_servconf_event_input.c am_servconf_nvram.c

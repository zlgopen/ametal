# Keil uVision project demo_mm32l373_core_boot_kft_application.uvprojx, settings and files
target debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ZLG217 Generic
  pack: ZLG.ZLG200_DFP.1.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo_mm32l373_core_boot_kft_application +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M3
  c include: ..\user_code;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config\am_servconf_usrcfg;..\..\..\..\..\3rdparty\CMSIS\Include;..\..\..\..\..\arch\arm\include;..\..\..\..\bsp_common\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\service\include;..\..\..\..\..\components\util\include;..\..\..\..\..\examples\board\mm32l373_core;..\..\..\..\..\examples\components;..\..\..\..\..\examples\soc\mm32;..\..\..\..\..\examples\std;..\..\..\..\..\interface;..\..\..\..\..\soc\mm32\mm32l373;..\..\..\..\..\soc\mm32\drivers\include\adc;..\..\..\..\..\soc\mm32\drivers\include\bkp;..\..\..\..\..\soc\mm32\drivers\include\bkp\hw;..\..\..\..\..\soc\mm32\drivers\include\clk;..\..\..\..\..\soc\mm32\drivers\include\cmp;..\..\..\..\..\soc\mm32\drivers\include\crc;..\..\..\..\..\soc\mm32\drivers\include\dac;..\..\..\..\..\soc\mm32\drivers\include\dma;..\..\..\..\..\soc\mm32\drivers\include\exti;..\..\..\..\..\soc\mm32\drivers\include\flash\hw;..\..\..\..\..\soc\mm32\drivers\include\gpio;..\..\..\..\..\soc\mm32\drivers\include\i2c;..\..\..\..\..\soc\mm32\drivers\include\pwr;..\..\..\..\..\soc\mm32\drivers\include\rcc;..\..\..\..\..\soc\mm32\drivers\include\spi;..\..\..\..\..\soc\mm32\drivers\include\syscfg\hw;..\..\..\..\..\soc\mm32\drivers\include\tim;..\..\..\..\..\soc\mm32\drivers\include\uart;..\..\..\..\..\soc\mm32\drivers\include\wdt;..\..\..\..\bsp_common\include;..\user_config;..\..\..\..\..\soc\mm32\drivers\include\gpio\hw;..\..\..\..\..\soc\mm32\drivers\include\pwr\hw;..\..\..\..\..\soc\mm32\drivers\include\rtc\hw;..\..\..\..\..\soc\mm32\drivers\include\afio\hw;..\..\..\..\..\soc\mm32\drivers\include\rcc\hw;..\..\..\..\..\soc\mm32\drivers\include\exti\hw;..\..\..\mm32l373_core;..\..\..\..\..\soc\mm32\drivers\include\adc;..\..\..\..\..\soc\mm32\drivers\include\adc\hw;..\..\..\..\..\soc\mm32\drivers\include\uart\hw;..\..\..\..\..\soc\mm32\drivers\include\flash;..\..\..\..\..\soc\mm32\drivers\include\crc\hw;..\..\..\..\..\soc\mm32\drivers\include\dac\hw;..\..\..\..\..\soc\mm32\drivers\include\dma\hw;..\..\..\..\..\soc\mm32\drivers\include\i2c\hw;..\..\..\..\..\soc\mm32\drivers\include\wdt\hw;..\..\..\..\..\soc\mm32\drivers\include\spi\hw;..\..\..\..\..\soc\mm32\drivers\include\tim\hw;..\..\..\..\..\arch\arm\include\hw;..\..\..\..\..\soc\mm32\drivers\include\rtc;..\..\..\..\..\examples\components;..\..\..\..\..\components\libc\newlib_adapter\include;..\..\..\..\..\soc\mm32\drivers\include\ili9341;..\..\..\..\..\components\libc\armlib_adapter\include;..\..\..\..\..\components\libc\microlib_adapter\include;..\..\..\..\..\components\libc\newlib_adapter\include;..\..\..\..\..\soc\mm32\drivers\include\can;..\..\..\..\..\soc\mm32\drivers\include\can\hw;..\..\..\..\..\soc\mm32\drivers\include\usbd;..\..\..\..\..\soc\mm32\drivers\include\usbd\hw;..\..\..\..\..\components\usb\device;..\..\..\..\..\components\usb\include;..\..\..\..\..\components\usb\osa;..\..\..\..\..\components\usb\host\config;..\..\..\..\..\components\usb\host\common\include;..\..\..\..\..\components\usb\host\class\include;..\..\..\..\..\components\usb\device\config\include;..\..\..\..\..\components\usb\host;..\..\..\mm32l373_core;..\..\..\..\..\soc\mm32\drivers\include\syscfg;..\..\..\..\..\components\drivers\source\lcd;..\..\..\..\..\examples\std;..\..\..\..\..\examples\soc\mm32;..\..\..\..\..\examples\components;..\..\..\..\..\components\bootloader\include\drivers;..\..\..\..\..\components\bootloader\include\core;..\..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool;..\..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool\drivers;..\..\..\..\..\soc\mm32\mm32l373\bootloader\include;..\..\..\..\..\components\service\include;..\user_config\am_bootconf_usrcfg
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\demo_mm32l373_core_boot_kft_application.sct
  group bsp_common
    ../../../../bsp_common/source/: am_bsp_armlib.c am_bsp_microlib.c am_bsp_delay_timer.c am_bsp_system_heap.c am_bsp_isr_defer_pendsv.c
  group arm
    ../../../../../arch/arm/source/: am_arm_nvic.c am_arm_nvic_armcc.s am_arm_systick.c
  group drivers
    ../../../../../components/drivers/source/adc/: am_cs1237.c
    ../../../../../components/drivers/source/ble/: am_zlg9021.c
    ../../../../../components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../../../../../components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../../../../../components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../../../../../components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../../../../../components/drivers/source/digitron_key/: am_zlg72128.c am_zlg72128_std.c
    ../../../../../components/drivers/source/fingerprint/: am_ts10x.c
    ../../../../../components/drivers/source/flash/: am_mx25xx.c
    ../../../../../components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../../../../../components/drivers/source/i2c/: am_i2c_gpio.c
    ../../../../../components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../../../../../components/drivers/source/led/: am_led_gpio.c am_led_hc595.c
    ../../../../../components/drivers/source/miniport/: am_miniport_view_key.c am_miniport_view_key_595.c
    ../../../../../components/drivers/source/nvram/: am_ep24cxx.c
    ../../../../../components/drivers/source/rtc/: am_ds1302.c am_pcf85063.c am_rx8025sa.c am_rx8025t.c
    ../../../../../components/drivers/source/sht20/: am_sht20.c
    ../../../../../components/drivers/source/spi/: am_spi_gpio.c
    ../../../../../components/drivers/source/temperature/: am_temp_lm75.c
    ../../../../../components/drivers/source/uart/: am_sc16is7xx.c
    ../../../../../components/drivers/source/zigbee/: am_zm516x.c
    ../../../../../components/drivers/source/zlg600/: am_zlg600.c
    ../../../../../components/drivers/source/lcd/: am_ili9341.c am_ili9341_intfc_3wire.c
  group libc
    ../../../../../components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../../../../../components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../../../../../components/service/source/: am_adc.c am_buzzer_dev.c am_event_category_input.c am_dac.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_timer.c am_uart.c am_uart_rngbuf.c am_crc_soft.c am_crc_table_def.c
  group util
    ../../../../../components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c
  group soc
    ../../../../../soc/mm32/drivers/source/adc/: am_mm32_adc.c
    ../../../../../soc/mm32/drivers/source/crc/: am_mm32_crc.c
    ../../../../../soc/mm32/drivers/source/dac/: am_mm32_dac.c
    ../../../../../soc/mm32/drivers/source/dma/: am_mm32_dma.c
    ../../../../../soc/mm32/drivers/source/flash/: am_mm32_flash.c
    ../../../../../soc/mm32/drivers/source/i2c/: am_mm32_i2c.c am_mm32_i2c_slv.c
    ../../../../../soc/mm32/drivers/source/spi/: am_mm32_spi_int.c am_mm32_spi_slv_dma.c am_mm32_spi_dma.c
    ../../../../../soc/mm32/drivers/source/tim/: am_mm32_tim_cap.c am_mm32_tim_pwm.c am_mm32_tim_timing.c
    ../../../../../soc/mm32/drivers/source/uart/: am_mm32_uart.c
    ../../../../../soc/mm32/drivers/source/uart/hw/: amhw_mm32_uart.c
    ../../../../../soc/mm32/drivers/source/wdt/: am_mm32_iwdg.c am_mm32_wwdg.c
    ../../../../../soc/mm32/drivers/source/rcc/hw/: amhw_mm32l373_rcc.c
    ../../../../../soc/mm32/drivers/source/gpio/: am_mm32l373_gpio.c
    ../../../../../soc/mm32/drivers/source/pwr/: am_mm32l373_pwr.c
    ../../../../../soc/mm32/drivers/source/clk/: am_mm32l373_clk.c
    ../../../../../soc/mm32/drivers/source/ili9341/: am_mm32_ili9341_3wire_spi.c
    ../../../../../soc/mm32/drivers/source/rtc/: am_mm32l373_rtc.c
    ../../../../../soc/mm32/mm32l373/bootloader/source/: am_mm32l373_boot.c am_mm32l373_boot_firmware_flash.c am_mm32l373_boot_flash.c am_mm32l373_boot_serial_uart.c
  group examples_board
    ../../../../../examples/board/mm32l373_core/adc/: demo_mm32l373_core_hw_adc_int.c demo_mm32l373_core_std_adc.c
    ../../../../../examples/board/mm32l373_core/buzzer/: demo_mm32l373_core_std_buzzer.c
    ../../../../../examples/board/mm32l373_core/clk/: demo_mm32l373_core_hw_clk.c
    ../../../../../examples/board/mm32l373_core/crc/: demo_mm32l373_core_std_crc.c
    ../../../../../examples/board/mm32l373_core/delay/: demo_mm32l373_core_std_delay.c
    ../../../../../examples/board/mm32l373_core/dma/: demo_mm32l373_core_drv_dma_m2m.c
    ../../../../../examples/board/mm32l373_core/flash/: demo_mm32l373_core_drv_flash.c
    ../../../../../examples/board/mm32l373_core/gpio/: demo_mm32l373_core_hw_gpio.c demo_mm32l373_core_hw_gpio_trigger.c demo_mm32l373_core_std_gpio.c demo_mm32l373_core_std_gpio_trigger.c
    ../../../../../examples/board/mm32l373_core/i2c/: demo_mm32l373_core_hw_i2c_master_poll.c demo_mm32l373_core_hw_i2c_slave_poll.c demo_mm32l373_core_std_i2c_lm75.c demo_mm32l373_core_std_i2c_master_async.c demo_mm32l373_core_std_i2c_master_sync.c
    ../../../../../examples/board/mm32l373_core/input_event/: demo_mm32l373_core_std_key_input_event.c
    ../../../../../examples/board/mm32l373_core/iwdg/: demo_mm32l373_core_hw_iwdg.c demo_mm32l373_core_std_iwdg.c
    ../../../../../examples/board/mm32l373_core/led/: demo_mm32l373_core_std_led.c
    ../../../../../examples/board/mm32l373_core/microport_board/: demo_mm32l373_core_microport_ds1302.c demo_mm32l373_core_microport_eeprom.c demo_mm32l373_core_microport_eeprom_nvram.c demo_mm32l373_core_microport_flash.c demo_mm32l373_core_microport_flash_ftl.c demo_mm32l373_core_microport_flash_mtd.c demo_mm32l373_core_microport_rs485.c demo_mm32l373_core_microport_rtc.c demo_mm32l373_core_microport_rx8025t.c
    ../../../../../examples/board/mm32l373_core/miniport_board/: demo_mm32l373_core_miniport_digitron.c demo_mm32l373_core_miniport_hc595_digitron.c demo_mm32l373_core_miniport_hc595_digitron_key.c demo_mm32l373_core_miniport_hc595_digitron_temp.c demo_mm32l373_core_miniport_hc595_led.c demo_mm32l373_core_miniport_key.c demo_mm32l373_core_miniport_key_digitron.c demo_mm32l373_core_miniport_led.c demo_mm32l373_core_miniport_zlg72128.c
    ../../../../../examples/board/mm32l373_core/rtc/: demo_mm32l373_core_std_rtc.c
    ../../../../../examples/board/mm32l373_core/spi/: demo_mm32l373_core_hw_spi_master.c demo_mm32l373_core_std_spi_master_dma.c demo_mm32l373_core_std_spi_master_int.c
    ../../../../../examples/board/mm32l373_core/timer/: demo_mm32l373_core_hw_tim_cap.c demo_mm32l373_core_hw_tim_cmp_toggle.c demo_mm32l373_core_hw_tim_pwm.c demo_mm32l373_core_hw_tim_timing.c demo_mm32l373_core_std_tim1_cap.c demo_mm32l373_core_std_tim1_pwm.c demo_mm32l373_core_std_tim1_timing.c demo_mm32l373_core_std_tim2_cap.c demo_mm32l373_core_std_tim2_pwm.c demo_mm32l373_core_std_tim2_timing.c demo_mm32l373_core_std_tim3_cap.c demo_mm32l373_core_std_tim3_pwm.c demo_mm32l373_core_std_tim3_timing.c demo_mm32l373_core_std_tim4_cap.c demo_mm32l373_core_std_tim4_pwm.c demo_mm32l373_core_std_tim4_timing.c
    ../../../../../examples/board/mm32l373_core/uart/: demo_mm32l373_core_hw_uart_int.c demo_mm32l373_core_hw_uart_polling.c demo_mm32l373_core_hw_uart_rx_dma.c demo_mm32l373_core_hw_uart_tx_dma.c demo_mm32l373_core_std_uart_polling.c demo_mm32l373_core_std_uart_ringbuf.c
    ../../../../../examples/board/mm32l373_core/wwdg/: demo_mm32l373_core_hw_wwdg.c demo_mm32l373_core_std_wwdg.c
    ../../../../../examples/board/mm32l373_core/bootloader_kft/: demo_mm32l373_core_boot_kft_application.c
  group examples_components
    ../../../../../examples/components/drivers/: demo_ep24cxx.c demo_mx25xx.c
    ../../../../../examples/components/service/: demo_ftl.c demo_mtd.c
  group examples_soc
    ../../../../../examples/soc/mm32/adc/: demo_mm32_hw_adc_int.c
    ../../../../../examples/soc/mm32/flash/: demo_mm32_drv_flash.c
    ../../../../../examples/soc/mm32/wakeup/: demo_mm32l373_drv_sleepmode_timer_wake_up.c demo_mm32l373_drv_sleepmode_wake_up.c demo_mm32l373_drv_standbymode_wake_up.c demo_mm32l373_drv_stopmode_wake_up.c
    ../../../../../examples/soc/mm32/dma/: demo_mm32_drv_dma_m2m.c
    ../../../../../examples/soc/mm32/gpio/: demo_mm32_hw_gpio_trigger.c demo_mm32_hw_gpio.c
    ../../../../../examples/soc/mm32/i2c/: demo_mm32_hw_i2c_master_poll.c demo_mm32_hw_i2c_slave_poll.c
    ../../../../../examples/soc/mm32/spi/: demo_mm32_hw_spi_master.c
    ../../../../../examples/soc/mm32/timer/: demo_mm32_hw_tim_cap.c demo_mm32_hw_tim_cmp_toggle.c demo_mm32_hw_tim_pwm.c demo_mm32_hw_tim_pwm_dead.c demo_mm32_hw_tim_timing.c
    ../../../../../examples/soc/mm32/uart/: demo_mm32_hw_uart_polling.c demo_mm32_hw_uart_rx_dma.c demo_mm32_hw_uart_tx_dma.c demo_mm32_hw_uart_int.c
    ../../../../../examples/soc/mm32/wdg/: demo_mm32_hw_iwdg.c demo_mm32_hw_wwdg.c
    ../../../../../examples/soc/mm32/clk/: demo_mm32_hw_clk.c
  group examples_std
    ../../../../../examples/std/adc/: demo_std_adc.c demo_std_adc_ntc.c
    ../../../../../examples/std/buzzer/: demo_std_buzzer.c
    ../../../../../examples/std/cap/: demo_std_timer_cap.c
    ../../../../../examples/std/crc/: demo_std_crc.c
    ../../../../../examples/std/delay/: demo_std_delay.c
    ../../../../../examples/std/digitron/: demo_std_digitron_60s_counting.c demo_std_digitron_temp.c
    ../../../../../examples/std/gpio/: demo_std_gpio.c demo_std_gpio_trigger.c
    ../../../../../examples/std/hc595/: demo_std_hc595_led.c
    ../../../../../examples/std/i2c/: demo_std_i2c_lm75.c demo_std_i2c_master_async.c demo_std_i2c_master_sync.c demo_std_i2c_slave.c demo_std_i2c_slave_subaddr.c
    ../../../../../examples/std/input/: demo_std_4key.c demo_std_key.c demo_std_key_digitron.c demo_std_key_digitron_rngbuf.c
    ../../../../../examples/std/led/: demo_std_led.c demo_std_led_water_light.c
    ../../../../../examples/std/nvram/: demo_std_nvram.c
    ../../../../../examples/std/pwm/: demo_std_timer_pwm.c
    ../../../../../examples/std/rtc/: demo_std_rtc.c
    ../../../../../examples/std/softimer/: demo_std_softimer.c
    ../../../../../examples/std/spi/: demo_std_spi_flash.c demo_std_spi_master.c demo_std_spi_slave.c
    ../../../../../examples/std/timer/: demo_std_timer_timing.c
    ../../../../../examples/std/uart/: demo_std_uart_polling.c demo_std_uart_ringbuf.c demo_std_uart_rs485.c
    ../../../../../examples/std/wdt/: demo_std_wdt.c
  group startup
    ../startup/: am_mm32l373_armcc_startup.s
  group user_code
    ../user_code/: main.c
  group user_config
    ../user_config/: am_prj_config.c am_board.c am_prj_config.h am_board.h am_mm32l373_inst_init.h
    ../user_config/am_hwconf_usrcfg/: am_hwconf_arm_nvic.c am_hwconf_buzzer_pwm.c am_hwconf_debug_uart.c am_hwconf_key_gpio.c am_hwconf_lcd_ili9341.c am_hwconf_led_gpio.c am_hwconf_lm75.c am_hwconf_microport_ds1302.c am_hwconf_microport_eeprom.c am_hwconf_microport_flash.c am_hwconf_microport_rs485.c am_hwconf_microport_rtc.c am_hwconf_microport_rx8025t.c am_hwconf_miniport_595.c am_hwconf_miniport_key.c am_hwconf_miniport_led.c am_hwconf_miniport_view.c am_hwconf_miniport_view_key.c am_hwconf_miniport_zlg72128.c am_hwconf_system_tick_softimer.c am_hwconf_mm32l373_adc.c am_hwconf_mm32l373_clk.c am_hwconf_mm32l373_crc.c am_hwconf_mm32l373_dac.c am_hwconf_mm32l373_dma.c am_hwconf_mm32l373_gpio.c am_hwconf_mm32l373_i2c.c am_hwconf_mm32l373_i2c_slv.c am_hwconf_mm32l373_iwdg.c am_hwconf_mm32l373_pwr.c am_hwconf_mm32l373_rtc.c am_hwconf_mm32l373_spi_dma.c am_hwconf_mm32l373_spi_int.c am_hwconf_mm32l373_systick.c am_hwconf_mm32l373_tim_cap.c am_hwconf_mm32l373_tim_pwm.c am_hwconf_mm32l373_tim_timing.c am_hwconf_mm32l373_uart.c am_hwconf_mm32l373_wwdg.c
    ../user_config/am_servconf_usrcfg/: am_servconf_event_input.c am_servconf_nvram.c
    ../user_config/am_bootconf_usrcfg/: am_bootconf_mm32l373_kft.c
  group bootloader
    ../../../../../components/bootloader/source/command_analyse/kboot_KinetisFlashTool/: am_boot_kft.c
    ../../../../../components/bootloader/source/command_analyse/kboot_KinetisFlashTool/drivers/: am_boot_kft_command.c am_boot_kft_property.c am_boot_kft_serial_packet.c
    ../../../../../components/bootloader/source/drivers/: am_boot_autobaud.c am_boot_flash_memory.c

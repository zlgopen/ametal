# Keil uVision project template_am237_core.uvprojx, settings and files
target debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ZLG217 Generic
  pack: ZLG.ZLG200_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template_am237_core +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M3
  c include: ..\user_code;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config\am_servconf_usrcfg;..\..\..\..\3rdparty\CMSIS\Include;..\..\..\..\arch\arm\include;..\..\..\bsp_common\include;..\..\..\..\components\drivers\include;..\..\..\..\components\service\include;..\..\..\..\components\util\include;..\..\..\..\interface;..\..\..\..\soc\zlg\drivers\include\adc;..\..\..\..\soc\zlg\drivers\include\bkp;..\..\..\..\soc\zlg\drivers\include\bkp\hw;..\..\..\..\soc\zlg\drivers\include\clk;..\..\..\..\soc\zlg\drivers\include\cmp;..\..\..\..\soc\zlg\drivers\include\crc;..\..\..\..\soc\zlg\drivers\include\dac;..\..\..\..\soc\zlg\drivers\include\dma;..\..\..\..\soc\zlg\drivers\include\exti;..\..\..\..\soc\zlg\drivers\include\flash\hw;..\..\..\..\soc\zlg\drivers\include\gpio;..\..\..\..\soc\zlg\drivers\include\i2c;..\..\..\..\soc\zlg\drivers\include\pwr;..\..\..\..\soc\zlg\drivers\include\rcc;..\..\..\..\soc\zlg\drivers\include\spi;..\..\..\..\soc\zlg\drivers\include\syscfg\hw;..\..\..\..\soc\zlg\drivers\include\tim;..\..\..\..\soc\zlg\drivers\include\uart;..\..\..\..\soc\zlg\drivers\include\wdt;..\..\..\bsp_common\include;..\user_config;..\..\..\..\soc\zlg\drivers\include\gpio\hw;..\..\..\..\soc\zlg\drivers\include\pwr\hw;..\..\..\..\soc\zlg\drivers\include\rtc\hw;..\..\..\..\soc\zlg\drivers\include\afio\hw;..\..\..\..\soc\zlg\drivers\include\rcc\hw;..\..\..\..\soc\zlg\drivers\include\exti\hw;..\..\..\..\soc\zlg\drivers\include\adc;..\..\..\..\soc\zlg\drivers\include\adc\hw;..\..\..\..\soc\zlg\drivers\include\uart\hw;..\..\..\..\soc\zlg\drivers\include\flash;..\..\..\..\soc\zlg\drivers\include\crc\hw;..\..\..\..\soc\zlg\drivers\include\dac\hw;..\..\..\..\soc\zlg\drivers\include\dma\hw;..\..\..\..\soc\zlg\drivers\include\i2c\hw;..\..\..\..\soc\zlg\drivers\include\wdt\hw;..\..\..\..\soc\zlg\drivers\include\spi\hw;..\..\..\..\soc\zlg\drivers\include\tim\hw;..\..\..\..\arch\arm\include\hw;..\..\..\..\soc\zlg\drivers\include\rtc;..\..\..\..\components\libc\newlib_adapter\include;..\..\..\..\soc\zlg\drivers\include\ili9341;..\..\..\..\components\libc\armlib_adapter\include;..\..\..\..\components\libc\microlib_adapter\include;..\..\..\..\components\libc\newlib_adapter\include;..\..\..\..\soc\zlg\drivers\include\can;..\..\..\..\soc\zlg\drivers\include\can\hw;..\..\..\..\soc\zlg\drivers\include\usbd;..\..\..\..\soc\zlg\drivers\include\usbd\hw;..\..\..\..\components\usb\device;..\..\..\..\components\usb\include;..\..\..\..\components\usb\osa;..\..\..\..\components\usb\host\config;..\..\..\..\components\usb\host\common\include;..\..\..\..\components\usb\host\class\include;..\..\..\..\components\usb\device\config\include;..\..\..\..\components\usb\host;..\..\..\..\soc\zlg\drivers\include\syscfg;..\..\..\..\components\drivers\source\lcd;..\..\..\..\soc\zlg\zlg237
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group bsp_common
    ../../../bsp_common/source/: am_bsp_armlib.c am_bsp_microlib.c am_bsp_delay_timer.c am_bsp_system_heap.c am_bsp_isr_defer_pendsv.c
  group arm
    ../../../../arch/arm/source/: am_arm_nvic.c am_arm_nvic_armcc.s am_arm_systick.c
  group drivers
    ../../../../components/drivers/source/adc/: am_cs1237.c
    ../../../../components/drivers/source/ble/: am_zlg9021.c am_zlg52810.c
    ../../../../components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../../../../components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../../../../components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../../../../components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../../../../components/drivers/source/digitron_key/: am_zlg72128_std.c zlg72128.c zlg72128_platform.c
    ../../../../components/drivers/source/fingerprint/: am_ts10x.c
    ../../../../components/drivers/source/flash/: am_mx25xx.c
    ../../../../components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../../../../components/drivers/source/i2c/: am_i2c_gpio.c
    ../../../../components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../../../../components/drivers/source/led/: am_led_gpio.c am_led_hc595.c
    ../../../../components/drivers/source/miniport/: am_miniport_view_key.c am_miniport_view_key_595.c
    ../../../../components/drivers/source/nvram/: am_ep24cxx.c
    ../../../../components/drivers/source/rtc/: am_ds1302.c am_pcf85063.c am_rx8025sa.c am_rx8025t.c
    ../../../../components/drivers/source/sht20/: am_sht20.c
    ../../../../components/drivers/source/spi/: am_spi_gpio.c
    ../../../../components/drivers/source/temperature/: am_temp_lm75.c
    ../../../../components/drivers/source/uart/: am_sc16is7xx.c
    ../../../../components/drivers/source/zigbee/: am_zm516x.c
    ../../../../components/drivers/source/zlg600/: am_zlg600.c
    ../../../../components/drivers/source/lcd/: am_ili9341.c am_ili9341_intfc_3wire.c
    ../../../../components/drivers/source/fm175xx/: am_fm175xx_zlg217.lib am_fm175xx_ant.c
    ../../../../components/drivers/source/fram/: am_fm25clxx.c
    ../../../../components/drivers/source/pt100/: am_pt100_to_temperature.c
    ../../../../components/drivers/source/thermocouple/: am_thermocouple.c
    ../../../../components/drivers/source/wdt/: am_cat823.c
    ../../../../components/drivers/source/sensor/: am_sensor_hts221.c
    ../../../../components/drivers/source/zsn603/: zsn603.c zsn603_platform.c
  group libc
    ../../../../components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../../../../components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../../../../components/service/source/: am_adc.c am_buzzer_dev.c am_event_category_input.c am_dac.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_timer.c am_uart.c am_uart_rngbuf.c am_crc_soft.c am_crc_table_def.c am_sdio.c am_sensor.c am_xmodem.c
  group util
    ../../../../components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c
  group soc
    ../../../../soc/zlg/drivers/source/adc/: am_zlg237_adc.c
    ../../../../soc/zlg/drivers/source/clk/: am_zlg237_clk.c
    ../../../../soc/zlg/drivers/source/crc/: am_zlg_crc.c
    ../../../../soc/zlg/drivers/source/dma/: am_zlg_dma.c
    ../../../../soc/zlg/drivers/source/flash/: am_zlg237_flash.c
    ../../../../soc/zlg/drivers/source/gpio/: am_zlg237_gpio.c
    ../../../../soc/zlg/drivers/source/rcc/hw/: amhw_zlg237_rcc.c
    ../../../../soc/zlg/drivers/source/rtc/: am_zlg237_rtc.c
    ../../../../soc/zlg/drivers/source/tim/: am_zlg_tim_cap.c am_zlg_tim_pwm.c am_zlg_tim_timing.c
    ../../../../soc/zlg/drivers/source/uart/: am_zlg237_usart.c
    ../../../../soc/zlg/drivers/source/uart/hw/: amhw_zlg237_usart.c
    ../../../../soc/zlg/drivers/source/wdt/: am_zlg_iwdg.c am_zlg_wwdg.c
    ../../../../soc/zlg/drivers/source/i2c/: am_zlg237_i2c.c am_zlg237_i2c_slv.c
    ../../../../soc/zlg/drivers/source/pwr/: am_zlg237_pwr.c
    ../../../../soc/zlg/drivers/source/spi/: am_zlg237_spi_dma.c am_zlg237_spi_int.c am_zlg237_spi_poll.c am_zlg237_spi_slv_dma.c
  group startup
    ../startup/: am_zlg237_armcc_startup.s
  group user_code
    ../user_code/: main.c
  group user_config
    ../user_config/am_hwconf_usrcfg/: am_hwconf_arm_nvic.c am_hwconf_buzzer_pwm.c am_hwconf_debug_uart.c am_hwconf_key_gpio.c am_hwconf_led_gpio.c am_hwconf_system_tick_softimer.c am_hwconf_zlg237_adc.c am_hwconf_zlg237_clk.c am_hwconf_zlg237_crc.c am_hwconf_zlg237_dma.c am_hwconf_zlg237_gpio.c am_hwconf_zlg237_iwdg.c am_hwconf_zlg237_rtc.c am_hwconf_zlg237_systick.c am_hwconf_zlg237_tim_cap.c am_hwconf_zlg237_tim_pwm.c am_hwconf_zlg237_tim_timing.c am_hwconf_zlg237_usart.c am_hwconf_zlg237_wwdg.c am_hwconf_fm175xx.c am_hwconf_lm75.c am_hwconf_microport_ds1302.c am_hwconf_microport_eeprom.c am_hwconf_microport_flash.c am_hwconf_microport_rs485.c am_hwconf_microport_rtc.c am_hwconf_microport_rx8025t.c am_hwconf_miniport_595.c am_hwconf_miniport_key.c am_hwconf_miniport_led.c am_hwconf_miniport_view.c am_hwconf_miniport_view_key.c am_hwconf_miniport_zlg72128.c am_hwconf_sensor_hts221.c am_hwconf_zlg237_i2c.c am_hwconf_zlg237_i2c_slv.c am_hwconf_zlg237_pwr.c am_hwconf_zlg237_spi_dma.c am_hwconf_zlg237_spi_int.c am_hwconf_zlg237_spi_poll.c am_hwconf_zlg237_spi_slv_dma.c
    ../user_config/am_servconf_usrcfg/: am_servconf_event_input.c am_servconf_nvram.c
    ../user_config/: am_board.c am_prj_config.c am_board.h am_prj_config.h am_zlg237_inst_init.h

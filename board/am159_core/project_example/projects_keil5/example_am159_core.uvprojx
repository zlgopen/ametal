# Keil uVision project example_am159_core.uvprojx, settings and files
target debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MM32F103VET MindMotion
  pack: MindMotion.MM32F103xCxE_DFP.1.0.3
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: example_am159 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M3
  c include: ..\user_code;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config\am_servconf_usrcfg;..\..\..\..\3rdparty\CMSIS\Include;..\..\..\..\arch\arm\include;..\..\..\bsp_common\include;..\..\..\..\components\drivers\include;..\..\..\..\components\service\include;..\..\..\..\components\util\include;..\..\..\..\examples\components;..\..\..\..\examples\soc\zlg;..\..\..\..\examples\std;..\..\..\..\interface;..\..\..\..\soc\zlg\drivers\include\adc;..\..\..\..\soc\zlg\drivers\include\bkp;..\..\..\..\soc\zlg\drivers\include\bkp\hw;..\..\..\..\soc\zlg\drivers\include\clk;..\..\..\..\soc\zlg\drivers\include\cmp;..\..\..\..\soc\zlg\drivers\include\crc;..\..\..\..\soc\zlg\drivers\include\dac;..\..\..\..\soc\zlg\drivers\include\dma;..\..\..\..\soc\zlg\drivers\include\exti;..\..\..\..\soc\zlg\drivers\include\flash\hw;..\..\..\..\soc\zlg\drivers\include\gpio;..\..\..\..\soc\zlg\drivers\include\i2c;..\..\..\..\soc\zlg\drivers\include\pwr;..\..\..\..\soc\zlg\drivers\include\rcc;..\..\..\..\soc\zlg\drivers\include\spi;..\..\..\..\soc\zlg\drivers\include\syscfg\hw;..\..\..\..\soc\zlg\drivers\include\tim;..\..\..\..\soc\zlg\drivers\include\uart;..\..\..\..\soc\zlg\drivers\include\wdt;..\..\..\bsp_common\include;..\user_config;..\..\..\..\soc\zlg\drivers\include\gpio\hw;..\..\..\..\soc\zlg\drivers\include\pwr\hw;..\..\..\..\soc\zlg\drivers\include\rtc\hw;..\..\..\..\soc\zlg\drivers\include\afio\hw;..\..\..\..\soc\zlg\drivers\include\rcc\hw;..\..\..\..\soc\zlg\drivers\include\exti\hw;..\..\..\am217_core;..\..\..\..\soc\zlg\drivers\include\adc;..\..\..\..\soc\zlg\drivers\include\adc\hw;..\..\..\..\soc\zlg\drivers\include\uart\hw;..\..\..\..\soc\zlg\drivers\include\flash;..\..\..\..\soc\zlg\drivers\include\crc\hw;..\..\..\..\soc\zlg\drivers\include\dac\hw;..\..\..\..\soc\zlg\drivers\include\dma\hw;..\..\..\..\soc\zlg\drivers\include\i2c\hw;..\..\..\..\soc\zlg\drivers\include\wdt\hw;..\..\..\..\soc\zlg\drivers\include\spi\hw;..\..\..\..\soc\zlg\drivers\include\tim\hw;..\..\..\..\arch\arm\include\hw;..\..\..\..\soc\zlg\drivers\include\rtc;..\..\..\..\examples\components;..\..\..\..\components\libc\newlib_adapter\include;..\..\..\..\soc\zlg\drivers\include\ili9341;..\..\..\..\components\libc\armlib_adapter\include;..\..\..\..\components\libc\microlib_adapter\include;..\..\..\..\components\libc\newlib_adapter\include;..\..\..\..\soc\zlg\drivers\include\can;..\..\..\..\soc\zlg\drivers\include\can\hw;..\..\..\..\soc\zlg\drivers\include\usbd;..\..\..\..\soc\zlg\drivers\include\usbd\hw;..\..\..\..\components\usb\device;..\..\..\..\components\usb\include;..\..\..\..\components\usb\osa;..\..\..\..\components\usb\host\config;..\..\..\..\components\usb\host\common\include;..\..\..\..\components\usb\host\class\include;..\..\..\..\components\usb\device\config\include;..\..\..\..\components\usb\host;..\..\..\..\soc\zlg\drivers\include\syscfg;..\..\..\..\components\drivers\source\lcd;..\..\..\..\soc\zlg\zmf159;..\..\..\..\examples\board\am159_core;..\..\..\..\components\usb;..\..\..\..\components\usb\osa;..\..\..\..\components\usb\include;..\..\..\..\components\usb\device;..\..\..\..\components\usb\device\common\include;..\..\..\..\components\usb\device\class\include;..\..\..\..\components\usb\osa;..\..\..\..\components\drivers\include;..\..\..\..\soc\zlg\drivers\include\sdio;..\..\..\..\components\bootloader\include\arch\arm;..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool;..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool\drivers;..\..\..\..\components\bootloader\include\core;..\..\..\..\components\bootloader\include\drivers;..\..\..\..\soc\zlg\drivers\include\eth\hw;..\..\..\..\soc\zlg\drivers\include\eth;..\..\..\..\soc\zlg\drivers\include\eth\lwip_adapter;..\..\..\..\soc\zlg\drivers\include\eth\lwip_adapter\arch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group bsp_common
    ../../../bsp_common/source/: am_bsp_armlib.c am_bsp_microlib.c am_bsp_delay_timer.c am_bsp_system_heap.c am_bsp_isr_defer_pendsv.c
  group arm
    ../../../../arch/arm/source/: am_arm_nvic.c am_arm_nvic_armcc.s am_arm_systick.c
  group drivers
    ../../../../components/drivers/source/adc/: am_cs1237.c
    ../../../../components/drivers/source/ble/: am_zlg9021.c
    ../../../../components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../../../../components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../../../../components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../../../../components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../../../../components/drivers/source/digitron_key/: am_zlg72128_std.c zlg72128.c zlg72128_platform.c
    ../../../../components/drivers/source/fingerprint/: am_ts10x.c
    ../../../../components/drivers/source/flash/: am_mx25xx.c
    ../../../../components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../../../../components/drivers/source/i2c/: am_i2c_gpio.c
    ../../../../components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../../../../components/drivers/source/led/: am_led_gpio.c am_led_hc595.c
    ../../../../components/drivers/source/miniport/: am_miniport_view_key.c am_miniport_view_key_595.c
    ../../../../components/drivers/source/nvram/: am_ep24cxx.c
    ../../../../components/drivers/source/rtc/: am_ds1302.c am_pcf85063.c am_rx8025sa.c am_rx8025t.c
    ../../../../components/drivers/source/sht20/: am_sht20.c
    ../../../../components/drivers/source/spi/: am_spi_gpio.c
    ../../../../components/drivers/source/temperature/: am_temp_lm75.c
    ../../../../components/drivers/source/uart/: am_sc16is7xx.c
    ../../../../components/drivers/source/zigbee/: am_zm516x.c
    ../../../../components/drivers/source/zlg600/: am_zlg600.c
    ../../../../components/drivers/source/lcd/: am_ili9341.c am_ili9341_intfc_3wire.c
    ../../../../components/drivers/source/sdcard/: am_sdcard.c
    ../../../../components/usb/: am_usbd_lib_m3.lib
  group libc
    ../../../../components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../../../../components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../../../../components/service/source/: am_adc.c am_buzzer_dev.c am_event_category_input.c am_dac.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_timer.c am_uart.c am_uart_rngbuf.c am_sdio.c
  group util
    ../../../../components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c
  group soc
    ../../../../soc/zlg/drivers/source/adc/: am_zlg_adc.c
    ../../../../soc/zlg/drivers/source/crc/: am_zlg_crc.c
    ../../../../soc/zlg/drivers/source/dac/: am_zlg_dac.c
    ../../../../soc/zlg/drivers/source/dma/: am_zlg_dma.c
    ../../../../soc/zlg/drivers/source/flash/: am_zlg_flash.c
    ../../../../soc/zlg/drivers/source/i2c/: am_zlg_i2c.c am_zlg_i2c_slv.c
    ../../../../soc/zlg/drivers/source/spi/: am_zlg_spi_dma.c am_zlg_spi_int.c am_zlg_spi_slv_dma.c am_zlg_spi_poll.c
    ../../../../soc/zlg/drivers/source/tim/: am_zlg_tim_cap.c am_zlg_tim_pwm.c am_zlg_tim_timing.c
    ../../../../soc/zlg/drivers/source/uart/: am_zlg_uart.c
    ../../../../soc/zlg/drivers/source/uart/hw/: amhw_zlg_uart.c
    ../../../../soc/zlg/drivers/source/wdt/: am_zlg_iwdg.c am_zlg_wwdg.c
    ../../../../soc/zlg/drivers/source/ili9341/: am_zlg_ili9341_3wire_spi.c
    ../../../../soc/zlg/drivers/source/clk/: am_zmf159_clk.c
    ../../../../soc/zlg/drivers/source/gpio/: am_zmf159_gpio.c
    ../../../../soc/zlg/drivers/source/pwr/: am_zmf159_pwr.c
    ../../../../soc/zlg/drivers/source/rtc/: am_zmf159_rtc.c
    ../../../../soc/zlg/drivers/source/usbd/: am_zmf159_usbd.c
    ../../../../components/usb/osa/: am_usb_osa_bm.c
    ../../../../soc/zlg/drivers/source/sdio/: am_zmf159_sdio.c
  group startup
    ../startup/: am_zmf159_armcc_startup.s
  group user_code
    ../user_code/: main.c
  group user_config
    ../user_config/: am_prj_config.c am_board.c am_prj_config.h am_board.h
    ../user_config/am_hwconf_usrcfg/: am_hwconf_arm_nvic.c am_hwconf_buzzer_pwm.c am_hwconf_debug_uart.c am_hwconf_key_gpio.c am_hwconf_led_gpio.c am_hwconf_lm75.c am_hwconf_microport_ds1302.c am_hwconf_microport_eeprom.c am_hwconf_microport_flash.c am_hwconf_microport_rs485.c am_hwconf_microport_rtc.c am_hwconf_microport_rx8025t.c am_hwconf_miniport_595.c am_hwconf_miniport_key.c am_hwconf_miniport_led.c am_hwconf_miniport_view.c am_hwconf_miniport_view_key.c am_hwconf_miniport_zlg72128.c am_hwconf_system_tick_softimer.c am_hwconf_microport.h am_hwconf_zmf159_adc.c am_hwconf_zmf159_clk.c am_hwconf_zmf159_crc.c am_hwconf_zmf159_dma.c am_hwconf_zmf159_gpio.c am_hwconf_zmf159_i2c.c am_hwconf_zmf159_i2c_slv.c am_hwconf_zmf159_iwdg.c am_hwconf_zmf159_pwr.c am_hwconf_zmf159_rtc.c am_hwconf_zmf159_spi_dma.c am_hwconf_zmf159_spi_int.c am_hwconf_zmf159_spi_poll.c am_hwconf_zmf159_spi_slv_dma.c am_hwconf_zmf159_systick.c am_hwconf_zmf159_tim_cap.c am_hwconf_zmf159_tim_pwm.c am_hwconf_zmf159_tim_timing.c am_hwconf_zmf159_uart.c am_hwconf_zmf159_wwdg.c am_hwconf_zmf159_usbd_printer.c am_hwconf_zmf159_usbd_vcom.c am_hwconf_zmf159_usb_keyboard.c am_hwconf_zmf159_usb_msc.c am_hwconf_zmf159_sdcard.c am_hwconf_zmf159_sdio.c
    ../user_config/am_servconf_usrcfg/: am_servconf_event_input.c am_servconf_nvram.c
  group example
    ../../../../examples/board/am159_core/adc/: demo_zmf159_core_hw_adc_int.c demo_zmf159_core_std_adc.c demo_zmf159_core_hw_adc_dma.c demo_zmf159_core_std_multichan_adc.c
    ../../../../examples/board/am159_core/buzzer/: demo_zmf159_core_std_buzzer.c
    ../../../../examples/board/am159_core/clk/: demo_zmf159_core_hw_clk.c
    ../../../../examples/board/am159_core/crc/: demo_zmf159_core_std_crc.c
    ../../../../examples/board/am159_core/delay/: demo_zmf159_core_std_delay.c
    ../../../../examples/board/am159_core/dma/: demo_zmf159_core_drv_dma_m2m.c
    ../../../../examples/board/am159_core/flash/: demo_zmf159_core_drv_flash.c
    ../../../../examples/board/am159_core/i2c/: demo_zmf159_core_hw_i2c_master_poll.c demo_zmf159_core_hw_i2c_slave_poll.c demo_zmf159_core_std_i2c_lm75.c demo_zmf159_core_std_i2c_master_async.c demo_zmf159_core_std_i2c_master_sync.c
    ../../../../examples/board/am159_core/input_event/: demo_zmf159_core_std_key_input_event.c
    ../../../../examples/board/am159_core/iwdg/: demo_zmf159_core_hw_iwdg.c demo_zmf159_core_std_iwdg.c
    ../../../../examples/board/am159_core/led/: demo_zmf159_core_std_led.c
    ../../../../examples/board/am159_core/rtc/: demo_zmf159_core_std_rtc.c
    ../../../../examples/board/am159_core/spi/: demo_zmf159_core_hw_spi_master.c demo_zmf159_core_std_spi_master_dma.c demo_zmf159_core_std_spi_master_int.c
    ../../../../examples/board/am159_core/uart/: demo_zmf159_core_hw_uart_int.c demo_zmf159_core_hw_uart_polling.c demo_zmf159_core_hw_uart_rx_dma.c demo_zmf159_core_hw_uart_tx_dma.c demo_zmf159_core_std_uart_polling.c demo_zmf159_core_std_uart_ringbuf.c
    ../../../../examples/board/am159_core/wakeup/: demo_zmf159_drv_sleepmode_timer_wake_up.c demo_zmf159_drv_sleepmode_wake_up.c demo_zmf159_drv_standbymode_wake_up.c demo_zmf159_drv_stopmode_wake_up.c
    ../../../../examples/board/am159_core/wwdg/: demo_zmf159_core_hw_wwdg.c demo_zmf159_core_std_wwdg.c
    ../../../../examples/soc/zlg/adc/: demo_zlg_hw_adc_int.c demo_zlg_hw_adc_dma.c
    ../../../../examples/soc/zlg/clk/: demo_zlg_hw_clk.c
    ../../../../examples/soc/zlg/dma/: demo_zlg_drv_dma_m2m.c
    ../../../../examples/soc/zlg/flash/: demo_zlg_drv_flash.c
    ../../../../examples/soc/zlg/gpio/: demo_zlg_hw_gpio.c demo_zlg_hw_gpio_trigger.c
    ../../../../examples/soc/zlg/i2c/: demo_zlg_hw_i2c_slave_poll.c demo_zlg_hw_i2c_master_poll.c
    ../../../../examples/soc/zlg/spi/: demo_zlg_hw_spi_master.c
    ../../../../examples/soc/zlg/timer/: demo_zlg_hw_tim_cap.c demo_zlg_hw_tim_cmp_toggle.c demo_zlg_hw_tim_pwm.c demo_zlg_hw_tim_pwm_dead.c demo_zlg_hw_tim_timing.c
    ../../../../examples/soc/zlg/uart/: demo_zlg_hw_uart_int.c demo_zlg_hw_uart_polling.c demo_zlg_hw_uart_rx_dma.c demo_zlg_hw_uart_tx_dma.c
    ../../../../examples/soc/zlg/wdg/: demo_zlg_hw_iwdg.c demo_zlg_hw_wwdg.c
    ../../../../examples/std/adc/: demo_std_adc.c demo_std_multichan_adc.c
    ../../../../examples/std/buzzer/: demo_std_buzzer.c
    ../../../../examples/std/crc/: demo_std_crc.c
    ../../../../examples/std/dac/: demo_std_dac.c
    ../../../../examples/std/delay/: demo_std_delay.c
    ../../../../examples/std/digitron/: demo_std_digitron_60s_counting.c demo_std_digitron_temp.c
    ../../../../examples/std/gpio/: demo_std_gpio_trigger.c demo_std_gpio.c
    ../../../../examples/std/hc595/: demo_std_hc595_led.c
    ../../../../examples/std/i2c/: demo_std_i2c_lm75.c demo_std_i2c_master_async.c demo_std_i2c_master_sync.c demo_std_i2c_slave.c demo_std_i2c_slave_subaddr.c
    ../../../../examples/std/input/: demo_std_4key.c demo_std_key.c demo_std_key_digitron.c demo_std_key_digitron_rngbuf.c
    ../../../../examples/std/led/: demo_std_led.c demo_std_led_water_light.c
    ../../../../examples/std/pwm/: demo_std_timer_pwm.c
    ../../../../examples/std/timer/: demo_std_timer_timing.c
    ../../../../examples/std/rtc/: demo_std_rtc.c
    ../../../../examples/std/wdt/: demo_std_wdt.c
    ../../../../examples/std/spi/: demo_std_spi_master.c
    ../../../../examples/std/uart/: demo_std_uart_ringbuf.c demo_std_uart_polling.c demo_std_uart_rs485.c
    ../../../../examples/std/cap/: demo_std_timer_cap.c
    ../../../../examples/board/am159_core/gpio/: demo_zmf159_core_hw_gpio.c demo_zmf159_core_hw_gpio_trigger.c demo_zmf159_core_std_gpio.c demo_zmf159_core_std_gpio_trigger.c
    ../../../../examples/board/am159_core/timer/: demo_zmf159_core_hw_tim_cap.c demo_zmf159_core_hw_tim_cmp_toggle.c demo_zmf159_core_hw_tim_pwm.c demo_zmf159_core_hw_tim_pwm_dead.c demo_zmf159_core_hw_tim_timing.c demo_zmf159_core_std_tim1_cap.c demo_zmf159_core_std_tim1_pwm.c demo_zmf159_core_std_tim1_timing.c demo_zmf159_core_std_tim2_cap.c demo_zmf159_core_std_tim2_pwm.c demo_zmf159_core_std_tim2_timing.c demo_zmf159_core_std_tim3_cap.c demo_zmf159_core_std_tim3_pwm.c demo_zmf159_core_std_tim3_timing.c demo_zmf159_core_std_tim4_cap.c demo_zmf159_core_std_tim4_pwm.c demo_zmf159_core_std_tim4_timing.c
    ../../../../examples/board/am159_core/microport_board/: demo_zmf159_core_microport_ds1302.c demo_zmf159_core_microport_eeprom.c demo_zmf159_core_microport_eeprom_nvram.c demo_zmf159_core_microport_flash.c demo_zmf159_core_microport_flash_ftl.c demo_zmf159_core_microport_flash_mtd.c demo_zmf159_core_microport_rs485.c demo_zmf159_core_microport_rtc.c demo_zmf159_core_microport_rx8025t.c
    ../../../../examples/board/am159_core/miniport_board/: demo_zmf159_core_miniport_digitron.c demo_zmf159_core_miniport_hc595_digitron.c demo_zmf159_core_miniport_hc595_digitron_key.c demo_zmf159_core_miniport_hc595_digitron_temp.c demo_zmf159_core_miniport_hc595_led.c demo_zmf159_core_miniport_key.c demo_zmf159_core_miniport_key_digitron.c demo_zmf159_core_miniport_led.c demo_zmf159_core_miniport_zlg72128.c
    ../../../../examples/components/drivers/: demo_ep24cxx.c demo_mx25xx.c demo_zlg9021_baudrate.c demo_zlg9021_led.c demo_zlg52810_baudrate.c demo_zm516x.c demo_zm516x_baudrate.c demo_zm516x_gpio.c demo_zm516x_key_led.c demo_zm516x_search.c
    ../../../../examples/components/service/: demo_ftl.c demo_mtd.c
    ../../../../examples/std/nvram/: demo_std_nvram.c
    ../../../../components/drivers/source/ble/: am_zlg52810.c
    ../../../../examples/soc/zlg/usbd/: demo_usbd_printer.c demo_usbd_printer_counter.c demo_usbd_vcom.c demo_usbd_keyboard.c demo_usbd_msc.c
    ../../../../examples/board/am159_core/usbd/: demo_zmf159_core_usbd_keyboard.c demo_zmf159_core_usbd_msc.c demo_zmf159_core_usbd_printer.c demo_zmf159_core_usbd_printer_counter.c demo_zmf159_core_usbd_vcom.c
    ../../../../examples/board/am159_core/sdcard/: demo_zmf159_core_std_sdcard.c
    ../../../../examples/std/sdcard/: demo_std_sdcard.c
target release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MM32F103VET MindMotion
  pack: MindMotion.MM32F103xCxE_DFP.1.0.3
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template_am159 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M3
  c include: ..\user_code;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config\am_servconf_usrcfg;..\..\..\..\3rdparty\CMSIS\Include;..\..\..\..\arch\arm\include;..\..\..\bsp_common\include;..\..\..\..\components\drivers\include;..\..\..\..\components\service\include;..\..\..\..\components\util\include;..\..\..\..\examples\components;..\..\..\..\examples\soc\zlg;..\..\..\..\examples\std;..\..\..\..\interface;..\..\..\..\soc\zlg\drivers\include\adc;..\..\..\..\soc\zlg\drivers\include\bkp;..\..\..\..\soc\zlg\drivers\include\bkp\hw;..\..\..\..\soc\zlg\drivers\include\clk;..\..\..\..\soc\zlg\drivers\include\cmp;..\..\..\..\soc\zlg\drivers\include\crc;..\..\..\..\soc\zlg\drivers\include\dac;..\..\..\..\soc\zlg\drivers\include\dma;..\..\..\..\soc\zlg\drivers\include\exti;..\..\..\..\soc\zlg\drivers\include\flash\hw;..\..\..\..\soc\zlg\drivers\include\gpio;..\..\..\..\soc\zlg\drivers\include\i2c;..\..\..\..\soc\zlg\drivers\include\pwr;..\..\..\..\soc\zlg\drivers\include\rcc;..\..\..\..\soc\zlg\drivers\include\spi;..\..\..\..\soc\zlg\drivers\include\syscfg\hw;..\..\..\..\soc\zlg\drivers\include\tim;..\..\..\..\soc\zlg\drivers\include\uart;..\..\..\..\soc\zlg\drivers\include\wdt;..\..\..\bsp_common\include;..\user_config;..\..\..\..\soc\zlg\drivers\include\gpio\hw;..\..\..\..\soc\zlg\drivers\include\pwr\hw;..\..\..\..\soc\zlg\drivers\include\rtc\hw;..\..\..\..\soc\zlg\drivers\include\afio\hw;..\..\..\..\soc\zlg\drivers\include\rcc\hw;..\..\..\..\soc\zlg\drivers\include\exti\hw;..\..\..\am217_core;..\..\..\..\soc\zlg\drivers\include\adc;..\..\..\..\soc\zlg\drivers\include\adc\hw;..\..\..\..\soc\zlg\drivers\include\uart\hw;..\..\..\..\soc\zlg\drivers\include\flash;..\..\..\..\soc\zlg\drivers\include\crc\hw;..\..\..\..\soc\zlg\drivers\include\dac\hw;..\..\..\..\soc\zlg\drivers\include\dma\hw;..\..\..\..\soc\zlg\drivers\include\i2c\hw;..\..\..\..\soc\zlg\drivers\include\wdt\hw;..\..\..\..\soc\zlg\drivers\include\spi\hw;..\..\..\..\soc\zlg\drivers\include\tim\hw;..\..\..\..\arch\arm\include\hw;..\..\..\..\soc\zlg\drivers\include\rtc;..\..\..\..\examples\components;..\..\..\..\components\libc\newlib_adapter\include;..\..\..\..\soc\zlg\drivers\include\ili9341;..\..\..\..\components\libc\armlib_adapter\include;..\..\..\..\components\libc\microlib_adapter\include;..\..\..\..\components\libc\newlib_adapter\include;..\..\..\..\soc\zlg\drivers\include\can;..\..\..\..\soc\zlg\drivers\include\can\hw;..\..\..\..\soc\zlg\drivers\include\usbd;..\..\..\..\soc\zlg\drivers\include\usbd\hw;..\..\..\..\components\usb\device;..\..\..\..\components\usb\include;..\..\..\..\components\usb\osa;..\..\..\..\components\usb\host\config;..\..\..\..\components\usb\host\common\include;..\..\..\..\components\usb\host\class\include;..\..\..\..\components\usb\device\config\include;..\..\..\..\components\usb\host;..\..\..\..\soc\zlg\drivers\include\syscfg;..\..\..\..\components\drivers\source\lcd;..\..\..\..\soc\zlg\zmf159
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000

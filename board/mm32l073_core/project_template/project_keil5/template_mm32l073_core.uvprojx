# Keil uVision project template_mm32l073_core.uvprojx, settings and files
target debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ZLG116 Generic
  pack: ZLG.ZLG100_DFP.1.0.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template_mm32l073_core +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M0
  c include: ..\user_code;..\user_config;..\user_config/am_hwconf_usrcfg;..\user_config/am_servconf_usrcfg;..\..\..\..\3rdparty/CMSIS/Include;..\..\..\..\arch/arm/include;..\..\..\..\board/bsp_common/include;..\..\..\..\components/drivers/include;..\..\..\..\components/libc/armlib_adapter/include;..\..\..\..\components/libc/microlib_adapter/include;..\..\..\..\components/service/include;..\..\..\..\components/util/include;..\..\..\..\examples/board/mm32l073_core;..\..\..\..\examples/components;..\..\..\..\examples/soc/mm32;..\..\..\..\examples/std;..\..\..\..\interface;..\..\..\..\soc/mm32/mm32l073;..\..\..\..\soc/mm32/drivers/include/adc;..\..\..\..\soc/mm32/drivers/include/bkp;..\..\..\..\soc/mm32/drivers/include/clk;..\..\..\..\soc/mm32/drivers/include/cmp;..\..\..\..\soc/mm32/drivers/include/crc;..\..\..\..\soc/mm32/drivers/include/dac;..\..\..\..\soc/mm32/drivers/include/dma;..\..\..\..\soc/mm32/drivers/include/exti;..\..\..\..\soc/mm32/drivers/include/flash;..\..\..\..\soc/mm32/drivers/include/gpio;..\..\..\..\soc/mm32/drivers/include/i2c;..\..\..\..\soc/mm32/drivers/include/pwr;..\..\..\..\soc/mm32/drivers/include/rcc;..\..\..\..\soc/mm32/drivers/include/spi;..\..\..\..\soc/mm32/drivers/include/syscfg;..\..\..\..\soc/mm32/drivers/include/tim;..\..\..\..\soc/mm32/drivers/include/uart;..\..\..\..\soc/mm32/drivers/include/wdt
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group bsp_common
    ../../../bsp_common/source/: am_bsp_armlib.c am_bsp_delay_timer.c am_bsp_isr_defer_pendsv.c am_bsp_microlib.c am_bsp_system_heap.c
  group arm
    ../../../../arch/arm/source/: am_arm_nvic.c am_arm_nvic_armcc.s am_arm_systick.c
  group drivers
    ../../../../components/drivers/source/zlg600/: am_zlg600.c
    ../../../../components/drivers/source/adc/: am_cs1237.c
    ../../../../components/drivers/source/ble/: am_zlg9021.c
    ../../../../components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../../../../components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../../../../components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../../../../components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../../../../components/drivers/source/digitron_key/: am_zlg72128.c am_zlg72128_std.c
    ../../../../components/drivers/source/fingerprint/: am_ts10x.c
    ../../../../components/drivers/source/flash/: am_mx25xx.c
    ../../../../components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../../../../components/drivers/source/i2c/: am_i2c_gpio.c
    ../../../../components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../../../../components/drivers/source/led/: am_led_hc595.c am_led_gpio.c
    ../../../../components/drivers/source/miniport/: am_miniport_view_key_595.c am_miniport_view_key.c
    ../../../../components/drivers/source/nvram/: am_ep24cxx.c
    ../../../../components/drivers/source/rtc/: am_ds1302.c am_pcf85063.c am_rx8025sa.c am_rx8025t.c
    ../../../../components/drivers/source/sht20/: am_sht20.c
    ../../../../components/drivers/source/spi/: am_spi_gpio.c
    ../../../../components/drivers/source/temperature/: am_temp_lm75.c
    ../../../../components/drivers/source/uart/: am_sc16is7xx.c
    ../../../../components/drivers/source/zigbee/: am_zm516x.c
    ../../../../components/drivers/source/fm175xx/: am_fm175xx_zlg116.lib
    ../../../../components/drivers/source/sensor/: am_sensor_hts221.c am_sensor_bme280.c am_sensor_bmp280.c am_sensor_lps22hb.c am_sensor_bh1730fvc.c am_sensor_bma253.c am_sensor_lis3mdl.c am_sensor_lsm6dsl.c am_sensor_shtc1.c
  group libc
    ../../../../components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../../../../components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../../../../components/service/source/: am_adc.c am_buzzer_dev.c am_dac.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_category_input.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_uart.c am_uart_rngbuf.c am_timer.c am_sensor.c
  group util
    ../../../../components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c
  group soc
    ../../../../soc/mm32/drivers/source/adc/: am_mm32_adc.c
    ../../../../soc/mm32/drivers/source/clk/: am_mm32l073_clk.c
    ../../../../soc/mm32/drivers/source/crc/: am_mm32_crc.c
    ../../../../soc/mm32/drivers/source/dac/: am_mm32_dac.c
    ../../../../soc/mm32/drivers/source/dma/: am_mm32_dma.c
    ../../../../soc/mm32/drivers/source/flash/: am_mm32_flash.c
    ../../../../soc/mm32/drivers/source/gpio/: am_mm32l073_gpio.c
    ../../../../soc/mm32/drivers/source/i2c/: am_mm32_i2c_slv.c am_mm32_i2c.c
    ../../../../soc/mm32/drivers/source/pwr/: am_mm32l073_pwr.c
    ../../../../soc/mm32/drivers/source/rcc/hw/: amhw_mm32l073_rcc.c
    ../../../../soc/mm32/drivers/source/spi/: am_mm32_spi_dma.c am_mm32_spi_int.c am_mm32_spi_slv_dma.c am_mm32_spi_poll.c
    ../../../../soc/mm32/drivers/source/tim/: am_mm32_tim_pwm.c am_mm32_tim_cap.c am_mm32_tim_timing.c
    ../../../../soc/mm32/drivers/source/uart/hw/: amhw_mm32_uart.c
    ../../../../soc/mm32/drivers/source/uart/: am_mm32_uart.c
    ../../../../soc/mm32/drivers/source/wdt/: am_mm32_iwdg.c am_mm32_wwdg.c
  group startup
    ../startup/: am_mm32l073_armcc_startup.s
  group user_code
    ../user_code/: main.c
  group user_config
    ../user_config/: am_prj_config.h am_board.h am_prj_config.c am_board.c am_mm32l073_inst_init.h
    ../user_config/am_hwconf_usrcfg/: am_hwconf_arm_nvic.c am_hwconf_buzzer_pwm.c am_hwconf_debug_uart.c am_hwconf_key_gpio.c am_hwconf_led_gpio.c am_hwconf_lm75.c am_hwconf_microport_ds1302.c am_hwconf_microport_eeprom.c am_hwconf_microport_flash.c am_hwconf_microport_rs485.c am_hwconf_microport_rtc.c am_hwconf_microport_rx8025t.c am_hwconf_miniport_595.c am_hwconf_miniport_key.c am_hwconf_miniport_led.c am_hwconf_miniport_view.c am_hwconf_miniport_view_key.c am_hwconf_miniport_zlg72128.c am_hwconf_system_tick_softimer.c am_hwconf_fm175xx.c am_hwconf_sensor_hts221.c am_hwconf_sensor_bmp280.c am_hwconf_sensor_bme280.c am_hwconf_sensor_lps22hb.c am_hwconf_sensor_bh1730fvc.c am_hwconf_sensor_bma253.c am_hwconf_sensor_lis3mdl.c am_hwconf_sensor_lsm6dsl.c am_hwconf_sensor_shtc1.c am_hwconf_mm32l073_adc.c am_hwconf_mm32l073_clk.c am_hwconf_mm32l073_dma.c am_hwconf_mm32l073_gpio.c am_hwconf_mm32l073_i2c.c am_hwconf_mm32l073_i2c_slv.c am_hwconf_mm32l073_iwdg.c am_hwconf_mm32l073_pwr.c am_hwconf_mm32l073_spi_dma.c am_hwconf_mm32l073_spi_int.c am_hwconf_mm32l073_spi_slv_dma.c am_hwconf_mm32l073_systick.c am_hwconf_mm32l073_tim_cap.c am_hwconf_mm32l073_tim_pwm.c am_hwconf_mm32l073_tim_timing.c am_hwconf_mm32l073_uart.c am_hwconf_mm32l073_wwdg.c am_hwconf_mm32l073_spi_poll.c
    ../user_config/am_servconf_usrcfg/: am_servconf_event_input.c am_servconf_nvram.c
target release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ZLG116 Generic
  pack: ZLG.ZLG100_DFP.1.0.1
  cpu: as above
  output: template_am116_core +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M0
  c include: ..\user_code;..\user_config;..\user_config/am_hwconf_usrcfg;..\user_config/am_servconf_usrcfg;..\..\..\..\3rdparty/CMSIS/Include;..\..\..\..\arch/arm/include;..\..\..\..\board/bsp_common/include;..\..\..\..\components/drivers/include;..\..\..\..\components/libc/armlib_adapter/include;..\..\..\..\components/libc/microlib_adapter/include;..\..\..\..\components/service/include;..\..\..\..\components/util/include;..\..\..\..\examples/board/am116_core;..\..\..\..\examples/components;..\..\..\..\examples/soc/zlg;..\..\..\..\examples/std;..\..\..\..\interface;..\..\..\..\soc/zlg/zlg116;..\..\..\..\soc/zlg/drivers/include/adc;..\..\..\..\soc/zlg/drivers/include/bkp;..\..\..\..\soc/zlg/drivers/include/clk;..\..\..\..\soc/zlg/drivers/include/cmp;..\..\..\..\soc/zlg/drivers/include/crc;..\..\..\..\soc/zlg/drivers/include/dac;..\..\..\..\soc/zlg/drivers/include/dma;..\..\..\..\soc/zlg/drivers/include/exti;..\..\..\..\soc/zlg/drivers/include/flash;..\..\..\..\soc/zlg/drivers/include/gpio;..\..\..\..\soc/zlg/drivers/include/i2c;..\..\..\..\soc/zlg/drivers/include/pwr;..\..\..\..\soc/zlg/drivers/include/rcc;..\..\..\..\soc/zlg/drivers/include/spi;..\..\..\..\soc/zlg/drivers/include/syscfg;..\..\..\..\soc/zlg/drivers/include/tim;..\..\..\..\soc/zlg/drivers/include/uart;..\..\..\..\soc/zlg/drivers/include/wdt
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
